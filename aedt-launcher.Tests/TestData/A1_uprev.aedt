$begin 'AnsoftProject'
	Created='Wed Sep  2 14:37:17 2026'
	Product='ElectronicsDesktop'
	FileOwnedByWorkbench=false
	$begin 'Desktop'
		Version(2026, 1)
		InfrastructureVersion(1, 0)
		$begin 'FactoryHeader'
			$begin 'geometry3deditor'
				KernelVersion(2, 0)
				ProjectContainsGeometry3D='1'
			$end 'geometry3deditor'
		$end 'FactoryHeader'
	$end 'Desktop'
	UsesAdvancedFeatures=false
	PreviewImageDesignId=1
	NextUniqueID=0
	MoveBackwards=false
	$begin 'HFSSEnvironment'
		Version(1, 0)
	$end 'HFSSEnvironment'
	$begin 'PlanarEMEnvironment'
		Version(1, 0)
	$end 'PlanarEMEnvironment'
	$begin 'Q3DEnvironment'
		Version(1, 0)
	$end 'Q3DEnvironment'
	$begin '2DExtractorEnvironment'
		Version(1, 0)
	$end '2DExtractorEnvironment'
	$begin 'NexximEnvironment'
		Version(1, 0)
	$end 'NexximEnvironment'
	$begin 'NexximNetlistEnvironment'
		Version(1, 0)
	$end 'NexximNetlistEnvironment'
	$begin 'EmitEnvironment'
		Version(1, 0)
	$end 'EmitEnvironment'
	$begin 'Maxwell3DEnvironment'
		Version(1, 0)
	$end 'Maxwell3DEnvironment'
	$begin 'Maxwell2DEnvironment'
		Version(1, 0)
	$end 'Maxwell2DEnvironment'
	$begin 'RMxprtEnvironment'
		Version(1, 0)
	$end 'RMxprtEnvironment'
	$begin 'MaxCirEnvironment'
		Version(1, 0)
	$end 'MaxCirEnvironment'
	$begin 'SimplorerEnvironment'
		Version(1, 0)
	$end 'SimplorerEnvironment'
	$begin 'IcepakEnvironment'
		Version(1, 0)
	$end 'IcepakEnvironment'
	$begin 'IcepakFEAEnvironment'
		Version(1, 0)
	$end 'IcepakFEAEnvironment'
	$begin 'SchematicEnvironment'
		Version(1, 0)
	$end 'SchematicEnvironment'
	$begin 'geometry3deditor'
		Version(1, 0)
	$end 'geometry3deditor'
	ReadVersion=12
	$begin 'EDB'
		Path=''
		LastUpdateTimeStamp=1788327437
	$end 'EDB'
	$begin 'DesignMgrEnvironment'
		CompInstCounter=2
		GPortCounter=0
		NetCounter=0
		Alias('Ieee;Simplorer Elements\\Ieee', 'Std;Simplorer Elements\\Std', 'Basic_VHDLAMS;Simplorer Elements\\Basic Elements VHDLAMS\\Basic Elements VHDLAMS', 'Digital_Elements;Simplorer Elements\\Digital Elements\\Digital Elements', 'Transformations;Simplorer Elements\\Tools\\Transformations\\Transformations', 'HEV_VHDLAMS;Simplorer Elements\\HEV VHDLAMS\\HEV VHDLAMS', 'automotive_vda;Simplorer Elements\\VDALibs VHDLAMS\\automotive_vda', 'example_boardnet;Simplorer Elements\\VDALibs VHDLAMS\\example_boardnet', 'example_ecar;Simplorer Elements\\VDALibs VHDLAMS\\example_ecar', 'fundamentals_vda;Simplorer Elements\\VDALibs VHDLAMS\\fundamentals_vda', 'hybrid_emc_vda;Simplorer Elements\\VDALibs VHDLAMS\\hybrid_emc_vda', 'megma;Simplorer Elements\\VDALibs VHDLAMS\\megma', 'modelica_rotational;Simplorer Elements\\VDALibs VHDLAMS\\modelica_rotational', 'modelica_thermal;Simplorer Elements\\VDALibs VHDLAMS\\modelica_thermal', 'modelica_translational;Simplorer Elements\\VDALibs VHDLAMS\\modelica_translational', 'spice2vhd;Simplorer Elements\\VDALibs VHDLAMS\\spice2vhd', 'spice2vhd_devices;Simplorer Elements\\VDALibs VHDLAMS\\spice2vhd_devices', 'aircraft_electrical_vhdlams;Simplorer Elements\\Aircraft Electrical VHDLAMS\\Aircraft Electrical VHDLAMS', 'power_system_vhdlams;Simplorer Elements\\Power System VHDLAMS\\Power System VHDLAMS')
	$end 'DesignMgrEnvironment'
	$begin 'ProjectDatasets'
		NextUniqueID=2
		MoveBackwards=false
		DatasetType='ProjectDatasetType'
		$begin 'DatasetDefinitions'
			$begin '$Cu_Pure_35'
				ID=0
				$begin 'Coordinates'
					DimUnits[2: '', '']
					Points[8: -273.15, 0.491183879093199, -196.15, 0.491183879093199, 99.85, 1, 726.85, 1]
				$end 'Coordinates'
			$end '$Cu_Pure_35'
			$begin '$Ceramic_material_39'
				ID=1
				$begin 'Coordinates'
					DimUnits[2: '', '']
					Points[8: -273.15, 0.067032967032967, -196.15, 0.067032967032967, 99.85, 1, 726.85, 1]
				$end 'Coordinates'
			$end '$Ceramic_material_39'
		$end 'DatasetDefinitions'
	$end 'ProjectDatasets'
	VariableOrders[0:]
	$begin 'Definitions'
		$begin 'Materials'
			$begin 'copper'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic', 'Thermal')
				$end 'PhysicsTypes'
				permeability='0.999991'
				conductivity='58000000'
				thermal_conductivity='400'
				mass_density='8933'
				specific_heat='385'
				ModTime=1524594782
				Library=''
				LibLocation='Project'
				ModSinceLib=true
			$end 'copper'
			$begin 'EDB_AIR'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic', 'Thermal')
				$end 'PhysicsTypes'
				permittivity='1'
				dielectric_loss_tangent='0'
				thermal_conductivity='0.0261'
				mass_density='1.1614'
				specific_heat='1005'
				ModTime=1524594782
				Library=''
				LibLocation='Project'
				ModSinceLib=true
			$end 'EDB_AIR'
			$begin 'EDB_CONFORMAL_COAT'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				permittivity='3'
				dielectric_loss_tangent='0.035'
				ModTime=1524594782
				Library=''
				LibLocation='Project'
				ModSinceLib=true
			$end 'EDB_CONFORMAL_COAT'
			$begin 'EDB_COPPER'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic', 'Thermal')
				$end 'PhysicsTypes'
				permeability='1'
				conductivity='59590000'
				thermal_conductivity='400'
				mass_density='8933'
				specific_heat='385'
				ModTime=1524594782
				Library=''
				LibLocation='Project'
				ModSinceLib=true
			$end 'EDB_COPPER'
			$begin 'EDB_FR-4'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				permittivity='4'
				dielectric_loss_tangent='0.035'
				ModTime=1524594782
				Library=''
				LibLocation='Project'
				ModSinceLib=true
			$end 'EDB_FR-4'
			$begin 'EDB_PLATED_COPPER_FOIL'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				permeability='1'
				conductivity='34300000'
				ModTime=1524594782
				Library=''
				LibLocation='Project'
				ModSinceLib=true
			$end 'EDB_PLATED_COPPER_FOIL'
			$begin 'FR4_epoxy'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic', 'Thermal', 'Structural')
				$end 'PhysicsTypes'
				$begin 'AttachedData'
					$begin 'MatAppearanceData'
						property_data='appearance_data'
						Red=27
						Green=110
						Blue=76
					$end 'MatAppearanceData'
				$end 'AttachedData'
				permittivity='4.4'
				dielectric_loss_tangent='0.02'
				thermal_conductivity='0.294'
				mass_density='1900'
				specific_heat='1150'
				youngs_modulus='11000000000'
				poissons_ratio='0.28'
				thermal_expansion_coefficient='1.5e-05'
				ModTime=1499970477
				Library='Materials'
				LibLocation='Project'
				ModSinceLib=true
			$end 'FR4_epoxy'
			$begin 'pec'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				$begin 'AttachedData'
					$begin 'MatAppearanceData'
						property_data='appearance_data'
						Red=247
						Green=242
						Blue=232
					$end 'MatAppearanceData'
				$end 'AttachedData'
				conductivity='1e+30'
				ModTime=1499970477
				Library='Materials'
				LibLocation='SysLibrary'
				ModSinceLib=false
			$end 'pec'
			$begin 'Al-Extruded'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Thermal')
				$end 'PhysicsTypes'
				$begin 'AttachedData'
					$begin 'MatAppearanceData'
						property_data='appearance_data'
						Red=232
						Green=235
						Blue=235
					$end 'MatAppearanceData'
				$end 'AttachedData'
				thermal_conductivity='205'
				mass_density='2800'
				specific_heat='900'
				youngs_modulus='69000000000'
				poissons_ratio='0.33'
				thermal_expansion_coefficient='2.277e-06'
				$begin 'thermal_material_type'
					property_type='ChoiceProperty'
					Choice='Solid'
				$end 'thermal_material_type'
				$begin 'clarity_type'
					property_type='ChoiceProperty'
					Choice='Opaque'
				$end 'clarity_type'
				ModTime=1592011950
				Library='Materials'
				LibLocation='SysLibrary'
				ModSinceLib=false
			$end 'Al-Extruded'
			$begin 'air'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic', 'Thermal')
				$end 'PhysicsTypes'
				$begin 'AttachedData'
					$begin 'MatAppearanceData'
						property_data='appearance_data'
						Red=230
						Green=230
						Blue=230
						Transparency=0.949999988079071
					$end 'MatAppearanceData'
				$end 'AttachedData'
				permittivity='1.0006'
				permeability='1.0000004'
				thermal_conductivity='0.0261'
				mass_density='1.1614'
				specific_heat='1005'
				thermal_expansion_coefficient='0.00333'
				$begin 'thermal_material_type'
					property_type='ChoiceProperty'
					Choice='Fluid'
				$end 'thermal_material_type'
				diffusivity='2.88e-05'
				molecular_mass='0.028966'
				viscosity='1.84e-05'
				material_refractive_index='1.000293'
				$begin 'clarity_type'
					property_type='ChoiceProperty'
					Choice='Transparent'
				$end 'clarity_type'
				ModTime=1592011950
				Library='Materials'
				LibLocation='SysLibrary'
				ModSinceLib=false
			$end 'air'
			$begin 'Cu-Pure'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Thermal')
				$end 'PhysicsTypes'
				$begin 'AttachedData'
					$begin 'MatAppearanceData'
						property_data='appearance_data'
						Red=242
						Green=140
						Blue=102
					$end 'MatAppearanceData'
				$end 'AttachedData'
				$begin 'ModifierData'
					$begin 'ThermalModifierData'
						modifier_data='thermal_modifier_data'
						$begin 'all_thermal_modifiers'
							$begin 'one_thermal_modifier'
								'Property:'='specific_heat'
								'Index:'=0
								prop_modifier='thermal_modifier'
								use_free_form=true
								free_form_value='pwl($Cu_Pure_35,Temp)'
							$end 'one_thermal_modifier'
						$end 'all_thermal_modifiers'
					$end 'ThermalModifierData'
				$end 'ModifierData'
				thermal_conductivity='387.6'
				mass_density='8933'
				specific_heat='397'
				$begin 'thermal_material_type'
					property_type='ChoiceProperty'
					Choice='Solid'
				$end 'thermal_material_type'
				$begin 'clarity_type'
					property_type='ChoiceProperty'
					Choice='Opaque'
				$end 'clarity_type'
				ModTime=1592011950
				Library='Materials'
				LibLocation='SysLibrary'
				ModSinceLib=false
			$end 'Cu-Pure'
			$begin 'FR-4'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Thermal')
				$end 'PhysicsTypes'
				$begin 'AttachedData'
					$begin 'MatAppearanceData'
						property_data='appearance_data'
						Red=27
						Green=110
						Blue=76
					$end 'MatAppearanceData'
				$end 'AttachedData'
				thermal_conductivity='0.35'
				mass_density='1250'
				specific_heat='1300'
				$begin 'thermal_material_type'
					property_type='ChoiceProperty'
					Choice='Solid'
				$end 'thermal_material_type'
				$begin 'clarity_type'
					property_type='ChoiceProperty'
					Choice='Opaque'
				$end 'clarity_type'
				ModTime=1592011950
				Library='Materials'
				LibLocation='SysLibrary'
				ModSinceLib=false
			$end 'FR-4'
			$begin 'IDF_BoardMaterial'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Thermal')
				$end 'PhysicsTypes'
				$begin 'thermal_conductivity'
					property_type='AnisoProperty'
					unit=''
					component1='21.1400858983536'
					component2='21.1400858983536'
					component3='0.426007067355781'
				$end 'thermal_conductivity'
				mass_density='1250'
				specific_heat='1300'
				ModTime=1788327307
				Library=''
				LibLocation='Project'
				ModSinceLib=false
			$end 'IDF_BoardMaterial'
			$begin 'Ceramic_material'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Thermal')
				$end 'PhysicsTypes'
				$begin 'AttachedData'
					$begin 'MatAppearanceData'
						property_data='appearance_data'
						Red=120
						Green=80
						Blue=0
					$end 'MatAppearanceData'
				$end 'AttachedData'
				$begin 'ModifierData'
					$begin 'ThermalModifierData'
						modifier_data='thermal_modifier_data'
						$begin 'all_thermal_modifiers'
							$begin 'one_thermal_modifier'
								'Property:'='specific_heat'
								'Index:'=0
								prop_modifier='thermal_modifier'
								use_free_form=true
								free_form_value='pwl($Ceramic_material_39,Temp)'
							$end 'one_thermal_modifier'
						$end 'all_thermal_modifiers'
					$end 'ThermalModifierData'
				$end 'ModifierData'
				thermal_conductivity='15'
				mass_density='3970'
				specific_heat='910'
				$begin 'thermal_material_type'
					property_type='ChoiceProperty'
					Choice='Solid'
				$end 'thermal_material_type'
				$begin 'clarity_type'
					property_type='ChoiceProperty'
					Choice='Opaque'
				$end 'clarity_type'
				ModTime=1592011950
				Library='Materials'
				LibLocation='SysLibrary'
				ModSinceLib=false
			$end 'Ceramic_material'
		$end 'Materials'
		$begin 'SurfaceMaterials'
			$begin 'Steel-oxidised-surface'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=2
				$begin 'PhysicsTypes'
					set('Thermal')
				$end 'PhysicsTypes'
				surface_emissivity='0.8'
				ModTime=1461288057
				Library='SurfaceMaterials'
				LibLocation='SysLibrary'
				ModSinceLib=false
			$end 'Steel-oxidised-surface'
		$end 'SurfaceMaterials'
		$begin 'Scripts'
		$end 'Scripts'
		$begin 'AnsysComponents'
			NextUniqueID=0
			MoveBackwards=false
			$begin 'AnsysComponentDefinitions'
			$end 'AnsysComponentDefinitions'
		$end 'AnsysComponents'
		$begin 'Symbols'
			$begin 'A1_uprev'
				ModTime=1788327111
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=true
				InitialLevels(0, 1)
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0.00254, 0.00254, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, 0.000423333333333333, 0.00254, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'A1_uprev'
			$begin 'IcepakDesign1'
				ModTime=1788327204
				CE=5
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=true
				InitialLevels(0, 1)
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0.00254, 0.00254, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, 0.000423333333333333, 0.00254, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'IcepakDesign1'
		$end 'Symbols'
		$begin 'DefInfo'
			A1_uprev(1002, 0, 16, 0, '', 1788327111, '', 'A1_uprev', '', '', '', '', '', '', '', 'Project', '', '', 1788327111, '', 0, 0)
			IcepakDesign1(0, 0, '', 1788327204, '', 'IcepakDesign1', '', '', '', '', '', 'Design.bmp', '', 'Project', '', '', 1788327204, '', 0)
		$end 'DefInfo'
		$begin 'Compdefs'
			$begin 'A1_uprev'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				$begin 'Properties'
					TextProp('Representation', 'D', '', 'A1_uprev')
				$end 'Properties'
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'A1_uprev'
			$begin 'IcepakDesign1'
				Library=''
				CircuitEnv=5
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				$begin 'Properties'
					TextProp('Representation', 'SRD', '', 'IcepakDesign1')
					TextProp('Owner', 'SRD', '', 'Icepak')
				$end 'Properties'
				CompExtID=6
			$end 'IcepakDesign1'
		$end 'Compdefs'
	$end 'Definitions'
	DesignIDServer=4
	MoveBackwards=false
	$begin 'PlanarEMCircuit'
		RepRewriteV2=true
		Name='A1_uprev'
		DesignID=0
		$begin 'Circuit'
			ComponentName='A1_uprev'
			AutoFP=''
			$begin 'DesignDatasets'
				NextUniqueID=0
				MoveBackwards=false
				DatasetType='DesignDatasetType'
				$begin 'DatasetDefinitions'
				$end 'DatasetDefinitions'
			$end 'DesignDatasets'
			VariableOrders[0:]
			$begin 'Net'
				NetName='12V_PEX'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='1V2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='3V3_AUX'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='3V3_PEX'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='3V3TMDS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='3V3TMDS_ADJ'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='3V3TMDS_IN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='5V'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='5V_IN_6529'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='6529_COMP'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='6529_COMP_CKTA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='6529_COMP_CKTB'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='6529_FET_OUT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='6529_FET_OUTB'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='6529_G'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='6529_GA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='6529_GB'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='6529_GH'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='6529_GL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='6529_LFB'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='6529_SW_FB'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='A3V3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='A3V3_ADJ'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ACALPD'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ACALPU'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='AGP_PLL_VDD'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='AGP_PME_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='AGPCLK_M'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='AGPDBI_HI'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='AGPDBI_LO'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='AGPMBDET'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='AGPRBF_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='AGPST0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='AGPST1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='AGPST2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='AGPSTB0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='AGPSTB0_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='AGPSTB1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='AGPSTB1_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='AGPSTOP'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='AGPVDDQ'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='AGPVREF'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='AGPWBF_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ATXC'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ATXC_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ATXD0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ATXD0_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ATXD1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ATXD1_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ATXD2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ATXD2_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='B_DDC_SCL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='B_DDC_SDA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='B_FB'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='B_FG'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='B_FR'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='B_M_BLUE'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='B_M_GREEN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='B_M_HSYNC'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='B_M_RED'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='B_M_VSYNC'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='BR02_AGP_APLL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='BR02_AGP_DPLL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='BR02_AGP_GPU'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='BR02_AGPCAL_GND'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='BR02_AGPCAL_VDDQ'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='BR02_DEVID0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='BR02_DEVID1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='BR02_DEVID2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='BR02_PEX_APLL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='BR02_PEX_DPLL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='BR02_REFCLK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='BR02_REFCLK_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='BR02_REFCLKA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='BR02_REFCLKA_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='BR02_TEST'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='BR02_VDD_PEX'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='BR02_XTAL_IN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='BR02_XTAL_OUT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='C_GND'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='CI2C_A_SCL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='CI2C_A_SDA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='CI2C_B_SCL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='CI2C_B_SDA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='CLK_OUT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='CLK_OUT_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='COMMON_REF'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='COUT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='CS0_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='CVBS_YOUT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DAC_A_BLUE'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DAC_A_GREEN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DAC_A_HS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DAC_A_RED'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DAC_A_RSET'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DAC_A_VDD'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DAC_A_VREF'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DAC_A_VS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DAC_B_BL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DAC_B_BLUE'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DAC_B_COUT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DAC_B_GN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DAC_B_GNA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DAC_B_GREEN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DAC_B_HS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DAC_B_RD'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DAC_B_RED'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DAC_B_VDD'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DAC_B_VREF'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DAC_B_VS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DAC_B_YOUT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DAC_B_YOUTA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DACAHSBUF'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DACAHSOUT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DACAVSBUF'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DACAVSOUT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DACB_RSET'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DACBHSBUF'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DACBHSOUT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DACBVSBUF'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DACBVSOUT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DCC_SDA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDC_SCL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDC_VCC'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DUMMY'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVI_HPD_C'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVI_HPD_F'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVI_HPD_F2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVOCAL_PD_VDDQ'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVOCAL_PU_GND'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVOCLKIN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVOD0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVOD1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVOD10'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVOD11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVOD2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVOD3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVOD4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVOD5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVOD6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVOD7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVOD8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVOD9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVODE'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVOHSYNC'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVOVDDQ'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVOVREF'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DVOVSYNC'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='EZ1085_ADJ'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='F5V'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FAN_ON'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FAN_RETURN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FB'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FB_DLLVDD'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAA0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAA1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAA10'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAA11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAA12'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAA2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAA3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAA4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAA5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAA6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAA7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAA8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAA9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAA_12'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBABA0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBABA1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBACAS_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBACKE'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBACLK0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBACLK0_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBACLK1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBACLK1_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBACS0_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD10'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD12'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD14'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD15'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD16'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD17'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD18'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD19'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD20'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD21'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD22'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD23'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD24'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD25'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD26'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD27'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD28'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD29'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD30'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD31'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD32'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD33'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD34'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD35'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD36'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD37'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD38'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD39'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD40'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD41'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD42'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD43'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD44'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD45'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD46'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD47'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD48'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD49'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD50'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD51'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD52'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD53'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD54'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD55'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD56'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD57'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD58'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD59'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD60'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD61'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD62'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD63'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAD9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBADQM0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBADQM1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBADQM2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBADQM3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBADQM4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBADQM5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBADQM6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBADQM7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBADQS0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBADQS1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBADQS2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBADQS3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBADQS4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBADQS5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBADQS6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBADQS7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBARAS_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBAWE_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBCAL_CLK_GND'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBCAL_PD_VDDQ'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBCAL_PU_GND'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBCAL_TERM_GND'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBVDD'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBVDDQ'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FBVREF'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FG'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='FR'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='GND'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='GPIO0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='GPIO2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='GPIO3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='I2C_A_SCL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='I2C_A_SDA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='I2C_B_SCL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='I2C_B_SDA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='I2CC_SCL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='I2CC_SDA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ICS9DB202_VDD'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ICS9DB202_VDDA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='IFPABPLLVDD'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='IFPABRSET'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='IFPABVREF'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='IFPAIOVDD'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='IFPATXC'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='IFPATXC_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='IFPATXD0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='IFPATXD0_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='IFPATXD1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='IFPATXD1_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='IFPATXD2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='IFPATXD2_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='IREF'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ISL6522_BOOT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ISL6522_COMP'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ISL6522_COMP_A'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ISL6522_EN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ISL6522_FB'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ISL6522_GH'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ISL6522_GH_A'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ISL6522_GL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ISL6522_GL_A'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ISL6522_OCSET'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ISL6522_PHASE'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ISL6522_PHASE_A'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ISL6522_PHASE_B'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ISL6522_RTIM'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ISL6522_SS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ISL6522_VCC'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ISL6522_VIN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JT_TCKA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JT_TDIA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JT_TDOA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JT_TMSA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JT_TRSTA_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TCLK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TDI'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TMS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TRST'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LOAD_TEST'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='M_BLUE'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='M_GREEN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='M_HSYNC'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='M_RED'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='M_VSYNC'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_6529_NC0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_6529_NC1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_6529_NC2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_6529_NC3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_A_MON_ID0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_A_MON_ID2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_B_MON_ID0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_B_MON_ID2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC10'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC12'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC14'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC15'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC16'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC17'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC18'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC19'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC20'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC21'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC22'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC23'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC24'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC25'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC26'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC27'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC28'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC29'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC30'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC31'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC32'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC33'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC34'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC35'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC36'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC37'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC38'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC39'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC40'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC41'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC42'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC43'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC44'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC45'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC46'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC47'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC48'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC49'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC50'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC51'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC52'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC53'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC54'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC55'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC56'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC57'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC58'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC59'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC60'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC61'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC62'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC63'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC64'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC65'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC66'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC67'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC68'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC69'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC70'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC71'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC72'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC73'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC74'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC75'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC76'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_NC9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_REFCLK_OUT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_BR02_REFCLK_OUT_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_DACC_BLUE'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_DACC_GREEN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_DACC_RED'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_DACC_RSET'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_DBIHI'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_DBILO'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_DEVSEL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_EPROM_NC1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_EPROM_NC2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_EPROM_NC3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_EPROM_NC4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBADQS_0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBADQS_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBADQS_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBADQS_3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBADQS_4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBADQS_5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBADQS_6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBADQS_7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCA0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCA1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCA10'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCA11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCA12'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCA2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCA3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCA4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCA5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCA6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCA7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCA8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCA9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCBA0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCBA1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCCAS_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCCKE'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCCLK0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCCLK0_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCCLK1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCCLK1_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCCS0_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCCS1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD10'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD12'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD14'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD15'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD16'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD17'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD18'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD19'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD20'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD21'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD22'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD23'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD24'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD25'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD26'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD27'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD28'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD29'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD30'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD31'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD32'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD33'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD34'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD35'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD36'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD37'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD38'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD39'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD40'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD41'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD42'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD43'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD44'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD45'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD46'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD47'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD48'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD49'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD50'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD51'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD52'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD53'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD54'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD55'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD56'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD57'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD58'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD59'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD60'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD61'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD62'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD63'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCD9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQM0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQM1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQM2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQM3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQM4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQM5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQM6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQM7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQS0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQS1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQS2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQS3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQS4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQS5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQS6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQS7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQS_0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQS_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQS_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQS_3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQS_4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQS_5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQS_6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCDQS_7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCRAS_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FBCWE_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_FRAME'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_GNT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_HRD1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_HRD3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC10'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC12'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC14'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC15'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC16'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC17'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC18'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC19'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC20'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC21'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC22'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ICS9DB202_NC9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_INTA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_IRDY'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_JT_TCKB'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_JT_TDIB'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_JT_TDOB'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_JT_TMSB'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_JT_TRSTB_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MBDET'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM1_NC1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM1_NC10'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM1_NC11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM1_NC12'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM1_NC13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM1_NC14'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM1_NC2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM1_NC3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM1_NC4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM1_NC5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM1_NC6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM1_NC7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM1_NC8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM1_NC9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM2_NC1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM2_NC10'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM2_NC11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM2_NC12'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM2_NC13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM2_NC14'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM2_NC2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM2_NC3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM2_NC4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM2_NC5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM2_NC6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM2_NC7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM2_NC8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_MEM2_NC9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_NC1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_NC2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_NC3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_NC4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_NC5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_PAR'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_PEX_25WBOOT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_PEX_SMCLK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_PEX_SMDAT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_PEX_TSTCLK_OUT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_PEX_TSTCLK_OUT_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_PRSNT2_B17'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_PRSNT2_B31'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_PRSNT2_B48'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_RBF'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_REQ'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_RSVD_A19'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_RSVD_A33'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_RSVD_A50'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_RSVD_B12'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_RSVD_B30'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_RSVD_B82'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_SBA0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_SBA1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_SBA2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_SBA3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_SBA4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_SBA5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_SBA6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_SBA7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_SBSTBF'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_SBSTBS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_SERR'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ST0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ST1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_ST2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_STOP'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_TMDSD3+'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_TMDSD3-'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_TMDSD4+'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_TMDSD4-'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_TMDSD5+'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_TMDSD5-'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_TRDY'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_VIPHAD1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_VTT_01'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_VTT_02'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_VTT_03'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_VTT_04'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_VTT_05'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_VTT_06'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_VTT_07'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_VTT_08'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_VTT_09'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_VTT_10'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_VTT_11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_VTT_12'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NTP_WBF'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NV34_HOTPLUG'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NV_HI_G'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NV_LO_G'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NVVDD'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD10'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD12'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD14'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD15'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD16'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD17'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD18'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD19'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD20'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD21'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD22'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD23'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD24'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD25'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD26'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD27'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD28'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD29'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD30'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD31'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIAD9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCICBE0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCICBE1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCICBE2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCICBE3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCICLK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIDEVSEL_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIFRAME_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIGNT_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIINTA_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIINTB_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIIRDY_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIPAR'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIREQ_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIRST_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCISTOP_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCITRDY_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_PRSNT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_REFCLK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_REFCLK_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_REFCLK_RSET'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RESET_IN_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RESET_INA_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX0_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX10'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX10_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX11_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX12'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX12_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX13_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX14'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX14_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX15'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX15_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX1_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX2_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX3_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX4_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX5_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX6_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX7_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX8_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_RX9_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX0A'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX0A_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX0B'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX0B_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX10A'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX10A_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX10B'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX10B_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX11A'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX11A_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX11B'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX11B_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX12A'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX12A_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX12B'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX12B_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX13A'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX13A_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX13B'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX13B_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX14A'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX14A_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX14B'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX14B_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX15A'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX15A_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX15B'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX15B_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX1A'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX1A_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX1B'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX1B_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX2A'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX2A_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX2B'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX2B_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX3A'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX3A_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX3B'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX3B_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX4A'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX4A_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX4B'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX4B_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX5A'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX5A_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX5B'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX5B_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX6A'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX6A_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX6B'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX6B_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX7A'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX7A_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX7B'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX7B_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX8A'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX8A_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX8B'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX8B_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX9A'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX9A_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX9B'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PEX_TX9B_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PLLVDD'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='QSEN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='RAM_CFG_0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='RAM_CFG_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ROMA14'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ROMA15'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ROMCS_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SBA0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SBA1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SBA2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SBA3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SBA4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SBA5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SBA6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SBA7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SBSTB'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SBSTB_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SEL_2ND_DEV'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='STRAP0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='STRAP1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='STRAP2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='STRAP3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SWAPRDY_A'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SWAPRDY_B'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TESTMEMCLK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TESTMODE'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='THERMDA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='THERMDC'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TIPPCLK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TMDSPLL_ADJ'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TMDSPLLVDD'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_AGPBUSY_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_BUFRST_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_DAC_B_BL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_DVOCLKOUT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_DVOCLKOUT_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_FBACS1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_FPBCLKOUT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_FPBCLKOUT_'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_FRWRLNKON'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_FRWRLPS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_GPIO4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_GPIO5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_GPIO6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_GPIO8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_GPIO9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_IFPBTXC+'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_IFPBTXC-'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_JTAG_TDO'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_PEX_WAKE'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_STEREO'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_TMDSD3+'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_TMDSD3-'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_TMDSD4+'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_TMDSD4-'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_TMDSD5+'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_TMDSD5-'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_TMDSD6+'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_TMDSD6-'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_TMDSD7+'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TP_TMDSD7-'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TVRSETEN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='VCCQS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='VIPCAL_PD_VDDQ'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='VIPCAL_PU_GND'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='VIPD0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='VIPD1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='VIPD2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='VIPD3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='VIPD4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='VIPD5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='VIPD6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='VIPD7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='VIPHAD0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='VIPHCLK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='VIPHCTL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='VREF_A'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='VREF_B'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='XTALIN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='XTALOUT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='XTALOUTBUFF'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='XTALSSIN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='Y_GND'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
		$end 'Circuit'
		$begin 'Layout'
			BlackBox=false
			DefUnits='mm'
			NIdx=5855
			ActLyr='TOP'
			Tol(1e-08, 1e-08, 1e-12)
			$begin 'HfssExportInfo'
				ScriptFileName=''
				HfssFileName=''
				Version=1
				ExtentType='BboxExtent'
				BasePolygon=''
				BasePolygonEDBUId=-1
				DielExtentType='BboxExtent'
				DielBasePolygon=''
				DielBasePolygonEDBUId=-1
				DielExt(Ext='0.005', Dim=false)
				HonorUserDiel=true
				Include3D=false
				TruncAtGnd=false
				AirHorExt(Ext='0.15', Dim=false)
				AirPosZExt(Ext='0.15', Dim=false)
				AirNegZExt(Ext='0.15', Dim=false)
				SyncZExt=true
				OpenRegionType='Radiation'
				UseRadBound=true
				PMLVisible=false
				OperFreq='5GHz'
				RadLvl=0
				UseStackupForZExtFact=false
				Smooth=true
			$end 'HfssExportInfo'
		$end 'Layout'
		$begin 'Port'
			$begin 'Data'
			$end 'Data'
			$begin 'CoupledPortsList'
			$end 'CoupledPortsList'
			$begin 'DiffPairs'
			$end 'DiffPairs'
			TotalVoltage=false
			IncludePortPostProcess=true
			$begin 'SortOrder'
			$end 'SortOrder'
			LegacySolverPinOrdering=false
		$end 'Port'
		$begin 'Boundary'
			$begin 'Data'
			$end 'Data'
			$begin 'CoupledPortsList'
			$end 'CoupledPortsList'
			$begin 'DiffPairs'
			$end 'DiffPairs'
			TotalVoltage=false
			IncludePortPostProcess=true
			$begin 'SortOrder'
			$end 'SortOrder'
			LegacySolverPinOrdering=false
		$end 'Boundary'
		$begin 'Cavity'
			$begin 'Data'
			$end 'Data'
		$end 'Cavity'
		$begin 'LayoutVia'
			$begin 'Data'
			$end 'Data'
		$end 'LayoutVia'
		$begin 'Source'
			$begin 'Data'
			$end 'Data'
		$end 'Source'
		$begin 'Voltage Probe'
			$begin 'Data'
			$end 'Data'
		$end 'Voltage Probe'
		$begin 'DC Terminal'
			$begin 'Data'
			$end 'Data'
		$end 'DC Terminal'
		$begin 'CircuitSources'
			$begin 'Data'
			$end 'Data'
		$end 'CircuitSources'
		$begin 'NexximPorts'
			$begin 'Data'
			$end 'Data'
			$begin 'DiffPairs'
			$end 'DiffPairs'
		$end 'NexximPorts'
		$begin 'SortOrder'
		$end 'SortOrder'
		$begin 'NexximMultiComponentContainers'
			$begin 'Data'
			$end 'Data'
		$end 'NexximMultiComponentContainers'
		$begin 'ComponentConfigurationData'
			$begin 'EnabledPorts'
			$end 'EnabledPorts'
			$begin 'EnabledMultipleComponents'
			$end 'EnabledMultipleComponents'
			$begin 'EnabledAnalyses'
			$end 'EnabledAnalyses'
		$end 'ComponentConfigurationData'
		$begin 'Properties'
		$end 'Properties'
		$begin 'CustomSimSetups'
			$begin 'Data'
			$end 'Data'
		$end 'CustomSimSetups'
		$begin 'RadSetup'
			$begin 'Data'
			$end 'Data'
		$end 'RadSetup'
		$begin 'Setup'
			$begin 'Data'
			$end 'Data'
		$end 'Setup'
		$begin 'AnalysisOptionBlocks'
		$end 'AnalysisOptionBlocks'
		$begin 'EM properties'
			$begin 'Data'
			$end 'Data'
		$end 'EM properties'
		$begin 'OutputVariable'
			NextUniqueID=0
			MoveBackwards=false
		$end 'OutputVariable'
		$begin 'Optimetrics'
			$begin 'OptimetricsSetups'
				NextUniqueID=0
				MoveBackwards=false
			$end 'OptimetricsSetups'
		$end 'Optimetrics'
		$begin 'FieldsReporter'
			$begin 'FieldsCalculator'
				Line_Discretization=1000
				'Show Stack'=true
			$end 'FieldsCalculator'
			$begin 'PlotDefaults'
				Default_SolutionId=-1
				Default_PlotFolder='Automatic'
			$end 'PlotDefaults'
			$begin 'FieldsPlotManagerID'
				NextUniqueID=0
				MoveBackwards=false
				NumQuantityType=0
				NumPlots=0
			$end 'FieldsPlotManagerID'
			$begin 'Report3dInGeomWnd'
				Report3dNum=0
			$end 'Report3dInGeomWnd'
			$begin 'Report2dInGeomWnd'
				Report2dNum=0
			$end 'Report2dInGeomWnd'
			$begin 'AntennaParametersInGeomWnd'
				AntennaParametersNum=0
			$end 'AntennaParametersInGeomWnd'
			AntennaParametersPlotTablesOrder()
			$begin 'EntitySelectionCache'
			$end 'EntitySelectionCache'
		$end 'FieldsReporter'
		$begin 'SolutionManager'
			$begin 'SimDataExtractors'
				$begin 'Version ID Map'
					V=0
				$end 'Version ID Map'
			$end 'SimDataExtractors'
		$end 'SolutionManager'
		$begin 'InterfaceOptions'
			SchematicEnabled=false
			SaveBeforeSolving=true
		$end 'InterfaceOptions'
		$begin 'AdvancedSettings'
			ComputeBothEvenAndOddCPWModes=false
			CausalMaterials=true
			MeshingMethod='Auto'
			EnableDesignIntersectionCheck=true
			UseAlternativeMeshMethodsAsFallBack=true
			CircuitSparamDefinition=false
			CircuitIntegrationType='FFT'
			BroadbandFreqOption='AutoMaxFreq'
			BroadbandMaxNumFreq=5
			SaveADP=false
			UseAdvancedDCExtrap=false
			ModeOption='General mode'
			PhiMesherDeltaZRatio=100000
			SpiceType='TouchStone1.0'
			EnforcePassivity=false
			EnforceCausality=false
			UseCommonGround=true
			ShowGammaComments=false
			Renormalize=true
			RenormImpedance=50
			FittingError=0.5
			MaxPoles=10000
			PassivityType='IteratedFittingOfPV'
			ColumnFittingType='Matrix'
			SSFittingType='FastFit'
			RelativeErrorToleranc=false
			EnsureAccurateZfit=true
			TouchstoneFormat='MA'
			TouchstoneUnits='GHz'
			TouchStonePrecision=15
			ExportAfterSolve=false
			ExportDir=''
		$end 'AdvancedSettings'
		$begin 'CoSimOptions'
			Override=false
			Setup=''
			OverrideSweep=false
			Sweep=''
			FrequencySweepType=0
			Interpolate=false
			YMatrix=true
			AutoAlignPorts=false
			Simulator=1
			InterpAlg='auto'
			Renormalize=false
			RenormImpedance=50
		$end 'CoSimOptions'
		$begin 'TemperatureData'
			IncludeTempDependence=false
			EnableFeedback=false
			Temperature='22cel'
		$end 'TemperatureData'
		$begin 'UserDefinedSolutionMgr'
			NextUniqueID=1000000
			MoveBackwards=false
		$end 'UserDefinedSolutionMgr'
		$begin 'DatasetSolutionMgr'
			NextUniqueID=2000000
			MoveBackwards=false
		$end 'DatasetSolutionMgr'
		Notes=$begin_cdata$ $end_cdata$
		$begin 'AnimationSetups'
		$end 'AnimationSetups'
		CacheHeaderFile='HDR2EE13071217883274375.tmp'
	$end 'PlanarEMCircuit'
	$begin 'IcepakModel'
		RepRewriteV2=true
		Name='IcepakDesign1'
		DesignID=2
		'Perform Minimal validation'=true
		'Default Fluid Material'='air'
		'Default Solid Material'='Al-Extruded'
		'Default Surface Material'='Steel-oxidised-surface'
		AmbientTemperature='20cel'
		AmbientPressure='0n_per_meter_sq'
		AmbientRadiationTemperature='20cel'
		'Gravity Vector CS ID'=1
		'Gravity Vector Axis'='Z'
		Positive=false
		ExportOnSimulationComplete=false
		ExportDirectory=''
		SherlockExportOnSimulationComplete=false
		SherlockExportAsFatigue=true
		SherlockExportDirectory=''
		AutoLaunchMeshViewer=true
		MeshCadAsLightWeight=true
		EnableTransitionTemplate=false
		TempSecondaryGradientSkewMesh=false
		EnableMeshByLayerFor2DMLM=false
		BoundaryBasedMeshRefinement=false
		EnableAltitudeEffects=false
		UpdateFanCurve=false
		Altitude='0meter'
		EnableIdealGasLaw=false
		OperatingPressure='101325n_per_meter_sq'
		EnableOperatingDensity=false
		OperatingDensity='1.225kg_per_m3'
		AppendTemplateToFieldsSummaryReport=false
		EnableLoadSolution=false
		CreateSolutionOverviewReport=true
		EnableMonitorOuputFrequency=true
		MonitorOutputFrequencyCount=1
		JouleHeatingType=0
		DisableShellConductionForJouleHeating=true
		$begin 'SolutionTypeOption'
			SolutionTypeOption='SteadyState'
			ProblemOption='TemperatureAndFlow'
		$end 'SolutionTypeOption'
		$begin 'OutputVariable'
			NextUniqueID=0
			MoveBackwards=false
		$end 'OutputVariable'
		$begin 'ModelSetup'
			$begin 'DesignDatasets'
				NextUniqueID=0
				MoveBackwards=false
				DatasetType='DesignDatasetType'
				$begin 'DatasetDefinitions'
				$end 'DatasetDefinitions'
			$end 'DesignDatasets'
			VariableOrders[0:]
			$begin 'Editor3D Doc Preferences'
				BackgroundColorVersion=1
				'Plane Background'=0
				'Need Lights'=true
				'Ambient Light'=8355711
				'Num Lights'=1
				Light0[4: 16777215, 0.75, -0.150000005960464, -0.629999995231628]
				Ver=2
			$end 'Editor3D Doc Preferences'
			SnapMode=31
			WorkingCS=1
			$begin 'GeometryCore'
				BlockVersionID=3
				DataVersion=1
				NativeKernel='PARASOLID'
				NativeKernelVersionID=26
				Units='mm'
				ModelExtents=10000
				InstanceID=-1
				$begin 'ValidationOptions'
					EntityCheckLevel='Basic'
					IgnoreUnclassifiedObjects=false
					SkipIntersectionChecks=false
				$end 'ValidationOptions'
				ContainsGeomLinkUDM=false
				$begin 'GeometryOperations'
					BlockVersionID=2
					$begin 'AnsoftRangedIDServerManager'
						$begin 'AnsoftRangedIDServer'
							IDServerObjectTypeID=0
							IDServerRangeMin=0
							IDServerRangeMax=2146483647
							NextUniqueID=24160
							MoveBackwards=false
						$end 'AnsoftRangedIDServer'
						$begin 'AnsoftRangedIDServer'
							IDServerObjectTypeID=1
							IDServerRangeMin=2146483648
							IDServerRangeMax=2146485547
							NextUniqueID=2146483654
							MoveBackwards=false
						$end 'AnsoftRangedIDServer'
					$end 'AnsoftRangedIDServerManager'
					StartBackGroundFaceID=2146483648
					$begin 'CoordinateSystems'
					$end 'CoordinateSystems'
					$begin 'OperandCSs'
					$end 'OperandCSs'
					$begin 'SubModelDefinitions'
					$end 'SubModelDefinitions'
					$begin 'Groups'
					$end 'Groups'
					$begin 'UserDefinedModels'
					$end 'UserDefinedModels'
					$begin 'OperandUserDefinedModels'
					$end 'OperandUserDefinedModels'
					$begin 'ToplevelParts'
						$begin 'GeometryPart'
							$begin 'Attributes'
								Name='Region'
								Flags='Wireframe#'
								Color='(255 0 0)'
								Transparency=0
								PartCoordinateSystem=1
								UDMId=-1
								GroupId=-1
								MaterialValue='"air"'
								SurfaceMaterialValue='""'
								SolveInside=true
								ShellElement=false
								ShellElementThickness='nan '
								ReferenceTemperature='20cel'
								IsMaterialEditable=true
								IsSurfaceMaterialEditable=true
								UseMaterialAppearance=false
								IsLightweight=false
								IsAlwaysHidden=false
							$end 'Attributes'
							$begin 'PhysicsAttributes'
								SuppressedForPhysics='False'
								SuppressedForPhysicsEditable=false
							$end 'PhysicsAttributes'
							$begin 'Operations'
								$begin 'Operation'
									OperationType='Region'
									ID=5
									ReferenceCoordSystemID=1
									$begin 'RegionParameters'
										KernelVersion=26
										'+XPaddingType'='Percentage Offset'
										'+XPadding'='50'
										'-XPaddingType'='Percentage Offset'
										'-XPadding'='50'
										'+YPaddingType'='Percentage Offset'
										'+YPadding'='50'
										'-YPaddingType'='Percentage Offset'
										'-YPadding'='50'
										'+ZPaddingType'='Percentage Offset'
										'+ZPadding'='50'
										'-ZPaddingType'='Percentage Offset'
										'-ZPadding'='50'
										$begin 'BoxForVirtualObjects'
											LowPoint[3: 1, 1, 1]
											HighPoint[3: -1, -1, -1]
										$end 'BoxForVirtualObjects'
									$end 'RegionParameters'
									ParentPartID=6
									ReferenceUDMID=-1
									IsSuppressed=false
									$begin 'OperationIdentity'
										$begin 'Topology'
											NumLumps=1
											NumShells=1
											NumFaces=6
											NumWires=0
											NumLoops=6
											NumCoedges=24
											NumEdges=12
											NumVertices=8
										$end 'Topology'
										BodyID=6
										StartFaceID=1321
										StartEdgeID=1327
										StartVertexID=1339
										NumNewFaces=6
										NumNewEdges=12
										NumNewVertices=8
										FaceNameAndIDMap()
										EdgeNameAndIDMap()
										VertexNameAndIDMap()
										IsXZ2DModeler=false
									$end 'OperationIdentity'
								$end 'Operation'
							$end 'Operations'
							$begin 'SubregionDependencyInformation'
								ChildSubregions[0:]
							$end 'SubregionDependencyInformation'
						$end 'GeometryPart'
					$end 'ToplevelParts'
					$begin 'OperandParts'
					$end 'OperandParts'
					$begin 'Planes'
					$end 'Planes'
					$begin 'Points'
					$end 'Points'
					$begin 'GeometryEntityLists'
					$end 'GeometryEntityLists'
					$begin 'RegionIdentity'
						$begin 'Topology'
							NumLumps=1
							NumShells=1
							NumFaces=6
							NumWires=0
							NumLoops=6
							NumCoedges=24
							NumEdges=12
							NumVertices=8
						$end 'Topology'
						BodyID=6
						StartFaceID=7
						StartEdgeID=13
						StartVertexID=25
						NumNewFaces=6
						NumNewEdges=12
						NumNewVertices=8
						FaceNameAndIDMap()
						EdgeNameAndIDMap()
						VertexNameAndIDMap()
						IsXZ2DModeler=false
					$end 'RegionIdentity'
					$begin 'CachedNames'
						$begin 'allobjects'
							allobjects(-1)
						$end 'allobjects'
						$begin 'global'
							global(-1)
						$end 'global'
						$begin 'model'
							model(-1)
						$end 'model'
						$begin 'region'
							region(-1)
						$end 'region'
					$end 'CachedNames'
				$end 'GeometryOperations'
				$begin 'GeometryDependencies'
					$begin 'DependencyInformation'
						NumParents=1
						DependencyObject('GeometryBodyOperation', 5)
						DependencyObject('CoordinateSystem', 1)
					$end 'DependencyInformation'
				$end 'GeometryDependencies'
			$end 'GeometryCore'
			$begin 'AssignedEntities'
				AssignedObject[0:]
			$end 'AssignedEntities'
			GroupByMaterial=true
			GroupSheetByMaterial=true
			GroupCompByDefID=true
			DoNotOrganizeUnderGroup=false
			DoNotOrganizeUnderComponent=false
			OrganizeLightweight=false
			ShowGroup=true
			$begin 'LastUserInputs'
			$end 'LastUserInputs'
		$end 'ModelSetup'
		$begin '3DComponent'
			$begin 'NativeComponentVisualization'
			$end 'NativeComponentVisualization'
		$end '3DComponent'
		$begin 'BoundarySetup'
			$begin 'GlobalBoundData'
			$end 'GlobalBoundData'
			$begin 'Boundaries'
				NextUniqueID=206
				MoveBackwards=false
			$end 'Boundaries'
			$begin 'ProductSpecificData'
			$end 'ProductSpecificData'
		$end 'BoundarySetup'
		$begin 'Monitor'
			$begin 'IcepakMonitors'
				NextUniqueID=0
				MoveBackwards=false
			$end 'IcepakMonitors'
		$end 'Monitor'
		$begin 'MeshRegion'
			$begin 'MeshSetup'
				NextUniqueID=1
				MoveBackwards=false
				$begin 'Global'
					DType='RegionT'
					ID=0
					IsComponent=false
					MeshMethod='MesherHD'
					UserSpecifiedSettings=false
					ComputeGap=true
					MeshRegionResolution=3
					GeometryBasedMeshing=false
					MinGapX='1mm'
					MinGapY='1mm'
					MinGapZ='1mm'
					Objects(6)
					StairStepSliderMeshing=false
					FacetLevel='3'
					ProximitySizeFunction=true
					CurvatureSizeFunction=true
					EnableTransition=false
					OptimizePCBMesh=true
					Enable2DCutCell=false
					EnforceCutCellMeshing=false
					Enforce2dot5DCutCell=false
					NonHDMesherEnabled=false
				$end 'Global'
			$end 'MeshSetup'
		$end 'MeshRegion'
		$begin 'AnalysisSetup'
			$begin 'DesignMeshLink'
				ImportMesh=false
			$end 'DesignMeshLink'
			$begin 'SolveSetups'
				NextUniqueID=0
				MoveBackwards=false
			$end 'SolveSetups'
		$end 'AnalysisSetup'
		$begin 'Optimetrics'
			$begin 'OptimetricsSetups'
				NextUniqueID=0
				MoveBackwards=false
			$end 'OptimetricsSetups'
		$end 'Optimetrics'
		$begin 'Solutions'
			$begin 'FieldsSummarySetting'
			$end 'FieldsSummarySetting'
		$end 'Solutions'
		$begin 'FieldsReporter'
			$begin 'FieldsCalculator'
				Line_Discretization=1000
				'Show Stack'=true
			$end 'FieldsCalculator'
			$begin 'PlotDefaults'
				Default_SolutionId=-1
				Default_PlotFolder='Automatic'
			$end 'PlotDefaults'
			$begin 'FieldsPlotManagerID'
				NextUniqueID=0
				MoveBackwards=false
				NumQuantityType=0
				NumPlots=0
			$end 'FieldsPlotManagerID'
			$begin 'Report3dInGeomWnd'
				Report3dNum=0
			$end 'Report3dInGeomWnd'
			$begin 'Report2dInGeomWnd'
				Report2dNum=0
			$end 'Report2dInGeomWnd'
			$begin 'AntennaParametersInGeomWnd'
				AntennaParametersNum=0
			$end 'AntennaParametersInGeomWnd'
			AntennaParametersPlotTablesOrder()
		$end 'FieldsReporter'
		$begin 'SolutionManager'
			$begin 'Version ID Map'
				V=3
			$end 'Version ID Map'
			ValidationCacheHeader=''
		$end 'SolutionManager'
		$begin 'UserDefinedSolutionMgr'
			NextUniqueID=1000000
			MoveBackwards=false
		$end 'UserDefinedSolutionMgr'
		$begin 'DatasetSolutionMgr'
			NextUniqueID=2000000
			MoveBackwards=false
		$end 'DatasetSolutionMgr'
		Notes=$begin_cdata$ $end_cdata$
		$begin 'AnimationSetups'
		$end 'AnimationSetups'
		CacheHeaderFile='HDR2EE13071217883274376.tmp'
	$end 'IcepakModel'
	$begin 'DataInstances'
		DesignEditor='TopLevel'
		Refdes('0', 'U1')
		Refdes('1', 'U2')
		$begin 'CompInstances'
			$begin 'Compinst'
				ID='0'
				Status='Status'
				CompName='A1_uprev'
				GatesInUse()
				$begin 'Properties'
					TextProp('ID', 'SRID', '', '0')
				$end 'Properties'
				$begin 'Parameters'
					MenuProp('CoSimulator', 'OHD', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'OHD', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
			$end 'Compinst'
			$begin 'Compinst'
				ID='1'
				Status='Status'
				CompName='IcepakDesign1'
				GatesInUse()
				$begin 'Properties'
					TextProp('ID', 'SRID', '', '1')
				$end 'Properties'
			$end 'Compinst'
		$end 'CompInstances'
		$begin 'Instance'
			DesignEditor='A1_uprev'
			ID='0'
			$begin 'PlanarEMItem'
				Editor3D=true
				$begin 'PostProcessing'
					DesignInstanceID=1
					$begin 'WindowPosition'
						$begin 'EditorWindow'
							Circuit(Layout(View(WindowPos(5, -1, -1, -8, -31, 0, 0, 136, 50), Extent(-2.71365642547607, -1, 2.71365642547607, 1, 44.4277530778368, 38.41206808793, -1.22524237632751, 0.0118106827139854, 2.58847212791443, 0.156200908124447, 1), ViewingXfm(-19.1266021728516, 18.8434600830078, -1.38194286823273, 0.909354090690613, 249.198791503906, 263.81591796875, 14.668909072876, 0, 0, 0, 0, 14.668909072876, 0, 0, 0, 0, 14.668909072876, 0, -1.15363264083862, 0.736104249954224, -256.518829345703, 1))), Layout())
						$end 'EditorWindow'
					$end 'WindowPosition'
					$begin 'ReportSetup'
						$begin 'ReportManager'
							$begin 'Reports'
							$end 'Reports'
							NextUniqueID=0
							MoveBackwards=false
							$begin 'NextVersID'
								NextUniqueID=0
								MoveBackwards=false
							$end 'NextVersID'
						$end 'ReportManager'
						$begin 'Reports'
						$end 'Reports'
						$begin 'ReportsWindowInfoList'
						$end 'ReportsWindowInfoList'
					$end 'ReportSetup'
				$end 'PostProcessing'
				$begin 'Properties'
				$end 'Properties'
				$begin 'UserDefinedDocument'
					$begin 'Data'
					$end 'Data'
				$end 'UserDefinedDocument'
			$end 'PlanarEMItem'
			$begin 'TopLayout'
				DefaultUnits='mm'
				DefaultAngleUnits='deg'
				MajorSize='10mm'
				MinorSize='1mm'
				PixelSnapTolerance=20
				SnapAcrossHierarchy=true
				SnapTargetVertex_on=true
				SnapTargetEdgeCenter_on=true
				SnapTargetObjCenter_on=true
				SnapTargetEdge_on=false
				SnapTargetElecConnection_on=true
				SnapTargetIntersection_on=false
				SnapTargetGrid_on=true
				SnapSourceVertex_on=true
				SnapSourceEdgeCenter_on=true
				SnapSourceObjCenter_on=true
				SnapSourceEdge_on=false
				SnapSourceElecConnection_on=true
				ConstrainToGrid=false
				DirectionConstraint=0
				defaultholesize='25mil'
				anglesnap='5deg'
				$begin 'NamingConvention'
					OptionUseNamingConvention_PadPort=false
					OptionNamingConvention_PadPort='$REFDES_$PINNAME_$NETNAME'
					OptionUseNamingConvention_EdgePort=false
					OptionNamingConvention_EdgePort='$NETNAME'
					OptionUseNamingConvention_PointPort=false
					OptionNamingConvention_PointPort='$POSTERM_LAYER_$NEGTERM_LAYER'
					OptionUseNamingConvention_PinGroup=false
					OptionNamingConvention_PinGroup='$REFDES_GROUP_$NETNAME'
					OptionUseNamingConvention_PinGroupPort=false
					OptionNamingConvention_PinGroupPort='$REFDES_$GROUPNAME_$NETNAME'
					OptionUseNamingConvention_PointISource=false
					OptionNamingConvention_PointISource='I_$POSTERM_NETNAME'
					OptionUseNamingConvention_PointVSource=false
					OptionNamingConvention_PointVSource='V_$POSTERM_NETNAME'
					OptionUseNamingConvention_PointVProbe=false
					OptionNamingConvention_PointVProbe='VP_$POSTERM_NETNAME'
					OptionUseNamingConvention_PointDCTerm=false
					OptionNamingConvention_PointDCTerm='DCT_$NETNAME'
					OptionUseNamingConvention_PinISource=false
					OptionNamingConvention_PinISource='I_$REFDES_$NETNAME'
					OptionUseNamingConvention_PinVSource=false
					OptionNamingConvention_PinVSource='V_$REFDES_$NETNAME'
					OptionUseNamingConvention_PinVProbe=false
					OptionNamingConvention_PinVProbe='VP_$REFDES_$NETNAME'
					OptionUseNamingConvention_PinDCTerm=false
					OptionNamingConvention_PinDCTerm='DCT_$REFDES_$NETNAME'
					OptionUseNamingConvention_GroupISource=false
					OptionNamingConvention_GroupISource='I_$REFDES_$NETNAME'
					OptionUseNamingConvention_GroupVSource=false
					OptionNamingConvention_GroupVSource='V_$REFDES_$NETNAME'
					OptionUseNamingConvention_GroupVProbe=false
					OptionNamingConvention_GroupVProbe='VP_$REFDES_$NETNAME'
					OptionUseNamingConvention_GroupDCTerm=false
					OptionNamingConvention_GroupDCTerm='DCT_$REFDES_$NETNAME'
					OptionUseNamingConvention_NCPortInstPort=false
					OptionNamingConvention_NCPortInstPort='$REFDES_$PORTNAME_$TERMNAME'
					''=false
					''=''
					''=false
					''=''
					''=false
					''=''
					''=false
					''=''
				$end 'NamingConvention'
				$begin 'TextStyles'
					TextStyle(N='<DefaultAnnotation>', F='Arial', Hght=12, Scale=false)
					TextStyle(N='<DefaultPlotter>', Plot=true, F='RomanSimplex', Hght=5, HghtUnt='mm')
					TextStyle(N='<DefaultMeasure>', F='Arial', Hght=12000, HghtUnt='mm')
				$end 'TextStyles'
				$begin 'TraceStyles'
					TraceStyle(name='Half Grid', size='0.5mm', bendStyle=0, capStyle=0, capStyle=0)
					TraceStyle(name='1 Grid', size='1mm', bendStyle=0, capStyle=0, capStyle=0)
					TraceStyle(name='2 Grids', size='2mm', bendStyle=0, capStyle=0, capStyle=0)
					TraceStyle(name='5 Grids', size='5mm', bendStyle=0, capStyle=0, capStyle=0)
				$end 'TraceStyles'
				'current via style'='PlanarEMVia'
				'current pin style'=''
				MajorColor=14599364
				MinorColor=15391450
				ShowGrid=true
				PageExtent(-0.1, -0.1, 0.1, 0.1)
				'background color'=16777215
				DefaultToSketchMode=true
				fillMode=false
				DocVisibilityFlag=962
				FastViewTransforms=true
				StartingHierarchyLevel=0
				EndingHierarchyLevel=-1
				SingleLevelView=false
				DesignMode=1
				Is2dRendering=false
				'show connection points'=false
				'draw rats'=false
				'display vertex labels'=false
				ColorByNet=false
				'display package graphics'=false
				'rectangle description'=0
				snaptoport=true
				autoplacecomp=false
				AutoScale=true
				'measure display digits'=3
				'display measure units'=true
				SuppressPads=true
				AntiPadsOption=1
				TextIsVisible=true
				'primary selection color'=255
				'secondary selection color'=3289780
				'selected transparent render'=true
				'selected solid render'=true
				'selected transparent render transparency'=90
				'preview selection'=false
				AllowDragOnFirstClick=false
				PinConnectivityPopup=false
				CreatePortsOnComp=false
				OptionUseNamingConvention_PadPort=false
				OptionNamingConvention_PadPort='$REFDES_$PINNAME_$NETNAME'
				OptionUseNamingConvention_EdgePort=false
				OptionNamingConvention_EdgePort='$NETNAME'
				OptionUseNamingConvention_PointPort=false
				OptionNamingConvention_PointPort='$POSTERM_LAYER_$NEGTERM_LAYER'
				OptionUseNamingConvention_PinGroup=false
				OptionNamingConvention_PinGroup='$REFDES_GROUP_$NETNAME'
				OptionUseNamingConvention_PinGroupPort=false
				OptionNamingConvention_PinGroupPort='$REFDES_$GROUPNAME_$NETNAME'
				OptionUseNamingConvention_PointISource=false
				OptionNamingConvention_PointISource='I_$POSTERM_NETNAME'
				OptionUseNamingConvention_PointVSource=false
				OptionNamingConvention_PointVSource='V_$POSTERM_NETNAME'
				OptionUseNamingConvention_PointVProbe=false
				OptionNamingConvention_PointVProbe='VP_$POSTERM_NETNAME'
				OptionUseNamingConvention_PointDCTerm=false
				OptionNamingConvention_PointDCTerm='DCT_$NETNAME'
				OptionUseNamingConvention_PinISource=false
				OptionNamingConvention_PinISource='I_$REFDES_$NETNAME'
				OptionUseNamingConvention_PinVSource=false
				OptionNamingConvention_PinVSource='V_$REFDES_$NETNAME'
				OptionUseNamingConvention_PinVProbe=false
				OptionNamingConvention_PinVProbe='VP_$REFDES_$NETNAME'
				OptionUseNamingConvention_PinDCTerm=false
				OptionNamingConvention_PinDCTerm='DCT_$REFDES_$NETNAME'
				OptionUseNamingConvention_GroupISource=false
				OptionNamingConvention_GroupISource='I_$REFDES_$NETNAME'
				OptionUseNamingConvention_GroupVSource=false
				OptionNamingConvention_GroupVSource='V_$REFDES_$NETNAME'
				OptionUseNamingConvention_GroupVProbe=false
				OptionNamingConvention_GroupVProbe='VP_$REFDES_$NETNAME'
				OptionUseNamingConvention_GroupDCTerm=false
				OptionNamingConvention_GroupDCTerm='DCT_$REFDES_$NETNAME'
				OptionUseNamingConvention_NCPortInstPort=false
				OptionNamingConvention_NCPortInstPort='$REFDES_$PORTNAME_$TERMNAME'
				''=false
				''=''
				''=false
				''=''
				''=false
				''=''
				''=false
				''=''
				useFixedDrawingResolution=false
				DrawingResolution='0.002mm'
				currentTextStyle=0
				currentTraceStyle=0
				prevBounds(-2.71365642547607, -1, 2.71365642547607, 1)
				prevMapFactor(44.4277530778368, 38.41206808793)
				prevOrigin(-1.22524237632751, 0.0118106827139854)
				prevViewExtent(2.58847212791443, 0.156200908124447)
				prevZoomScale=1
				$begin 'ViewConfigs'
					ViewConfigsCurrent=''
				$end 'ViewConfigs'
				$begin 'Animation'
					LabelColor(R=230, G=230, B=230)
					FontName='Arial'
					FontHeight=24
					FontWeight=400
				$end 'Animation'
				$begin 'AutoHFSSRegions'
					UseMinValue=false
					MinValue=4
					CreatePadding=false
					PaddingValue=0
				$end 'AutoHFSSRegions'
			$end 'TopLayout'
		$end 'Instance'
		$begin 'Instance'
			DesignEditor='IcepakDesign1'
			ID='1'
			$begin 'IcepakDesignInstance'
				DesignInstanceID=3
				$begin 'WindowPosition'
					$begin 'EditorWindow'
						Circuit(Editor3d(View('View Orientation Gadget'=1, WindowPos(3, -1, -1, -8, -31, 26, 26, 533, 504), OrientationMatrix(0.00305860675871372, 0.000491162063553929, -0.000517694221343845, 0, -0.000707654631696641, 0.00238205818459392, -0.00192070158664137, 0, 9.22761100810021e-05, 0.00198710500262678, 0.00243042223155499, 0, -0.309434592723846, 0.242302924394608, -5.4224534034729, 1, 0, -0.184486776590347, 0.0548353269696236, -0.016755223274231, 0.321869909763336, 2.07693719863892, 8.61952781677246), Drawings[1: 'Region'], 'View Data'('Render Mode'=1, 'Show Ruler'=1, 'Coordinate Systems View Mode'=1, 'CS Triad View Mode'=0, 'Render Facets'=1, GridVisible=1, GridAutoAdjust=1, GridAutoExtents=1, GridType='Rect', GridStyle='Line', NumPixels=30, dXForGrid=5, dYForGrid=5, dZForGrid=5, dRForGrid=5, dThetaForGrid=10), ClipPlanes(ClipPlaneOptions(DisableWhenDrawingNewPlane=true, ForceOpqaueForUnclipped=false, ShowClipped=false, Transparency=0, HandleColor=16776960)))))
					$end 'EditorWindow'
				$end 'WindowPosition'
				$begin 'ReportSetup'
					$begin 'ReportManager'
						$begin 'Reports'
						$end 'Reports'
						NextUniqueID=0
						MoveBackwards=false
						$begin 'NextVersID'
							NextUniqueID=0
							MoveBackwards=false
						$end 'NextVersID'
					$end 'ReportManager'
					$begin 'Reports'
					$end 'Reports'
					$begin 'ReportsWindowInfoList'
					$end 'ReportsWindowInfoList'
				$end 'ReportSetup'
				$begin 'Properties'
				$end 'Properties'
				$begin 'UserDefinedDocument'
					$begin 'Data'
					$end 'Data'
				$end 'UserDefinedDocument'
			$end 'IcepakDesignInstance'
		$end 'Instance'
		$begin 'SODInfo'
			$begin 'A1_uprev'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'A1_uprev'
		$end 'SODInfo'
	$end 'DataInstances'
	$begin 'WBSystemIDToDesignInstanceIDMap'
	$end 'WBSystemIDToDesignInstanceIDMap'
	$begin 'WBSysIDSysDetails'
	$end 'WBSysIDSysDetails'
	$begin 'WBConnIDConnDetails'
	$end 'WBConnIDConnDetails'
	$begin 'WBMaterialGuidDetails'
		WBMaterialGuidMap()
	$end 'WBMaterialGuidDetails'
	$begin 'MinervaProjectSettingsBlk'
		MinervaRemoteFilePath=''
		FolderContainerString=''
	$end 'MinervaProjectSettingsBlk'
$end 'AnsoftProject'
$begin 'AllReferencedFilesForProject'
$end 'AllReferencedFilesForProject'
$begin 'ProjectPreview'
	ProductName='ElectronicsDesktop'
	MajorVersion=2026
	MinorVersion=1
	IsEncrypted=false
	Thumbnail64='/9j/4AAQSkZJRgABAQAAAQABAAD/2wBDAAEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQE\
BAQICAQECAQEBAgICAgICAgICAQICAgICAgICAgL/2wBDAQEBAQEBAQEBAQECAQEBAgICAgICAgICAg\
ICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgL/wAARCABgAGADASIAAhEBAxEB/\
8QAHwAAAQUBAQEBAQEAAAAAAAAAAAECAwQFBgcICQoL/8QAtRAAAgEDAwIEAwUFBAQAAAF9AQIDAAQR\
BRIhMUEGE1FhByJxFDKBkaEII0KxwRVS0fAkM2JyggkKFhcYGRolJicoKSo0NTY3ODk6Q0RFRkdISUp\
TVFVWV1hZWmNkZWZnaGlqc3R1dnd4eXqDhIWGh4iJipKTlJWWl5iZmqKjpKWmp6ipqrKztLW2t7i5us\
LDxMXGx8jJytLT1NXW19jZ2uHi4+Tl5ufo6erx8vP09fb3+Pn6/8QAHwEAAwEBAQEBAQEBAQAAAAAAA\
AECAwQFBgcICQoL/8QAtREAAgECBAQDBAcFBAQAAQJ3AAECAxEEBSExBhJBUQdhcRMiMoEIFEKRobHB\
CSMzUvAVYnLRChYkNOEl8RcYGRomJygpKjU2Nzg5OkNERUZHSElKU1RVVldYWVpjZGVmZ2hpanN0dXZ\
3eHl6goOEhYaHiImKkpOUlZaXmJmaoqOkpaanqKmqsrO0tba3uLm6wsPExcbHyMnK0tPU1dbX2Nna4u\
Pk5ebn6Onq8vP09fb3+Pn6/9oADAMBAAIRAxEAPwD+/iiiigAooooAKKKKACiiigAooooAKKKKACiii\
gAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACii\
igAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKAPMf+Eh1j/n8/wDJe1/+MVqaNrOpXepW1vc\
XPmQyedvTybdM7LeV1+ZIgR8yqeD29K5Gtrw9/wAhiz/7eP8A0lnoA9OooooAKKKKACiiigAooooAKK\
KKAP/Z'
	$begin 'DesignInfo'
		DesignName='A1_uprev'
		Notes=''
		Factory='HFSS 3D Layout Design'
		IsSolved=false
		'Nominal Setups'[0:]
		'Nominal Setup Types'[0:]
		'Optimetrics Setups'[0:]
		'Optimetrics Experiment Types'[0:]
		Image64='/9j/4AAQSkZJRgABAQAAAQABAAD/2wBDAAEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQE\
BAQICAQECAQEBAgICAgICAgICAQICAgICAgICAgL/2wBDAQEBAQEBAQEBAQECAQEBAgICAgICAgICAg\
ICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgL/wAARCADIAMgDASIAAhEBAxEB/\
8QAHwAAAQUBAQEBAQEAAAAAAAAAAAECAwQFBgcICQoL/8QAtRAAAgEDAwIEAwUFBAQAAAF9AQIDAAQR\
BRIhMUEGE1FhByJxFDKBkaEII0KxwRVS0fAkM2JyggkKFhcYGRolJicoKSo0NTY3ODk6Q0RFRkdISUp\
TVFVWV1hZWmNkZWZnaGlqc3R1dnd4eXqDhIWGh4iJipKTlJWWl5iZmqKjpKWmp6ipqrKztLW2t7i5us\
LDxMXGx8jJytLT1NXW19jZ2uHi4+Tl5ufo6erx8vP09fb3+Pn6/8QAHwEAAwEBAQEBAQEBAQAAAAAAA\
AECAwQFBgcICQoL/8QAtREAAgECBAQDBAcFBAQAAQJ3AAECAxEEBSExBhJBUQdhcRMiMoEIFEKRobHB\
CSMzUvAVYnLRChYkNOEl8RcYGRomJygpKjU2Nzg5OkNERUZHSElKU1RVVldYWVpjZGVmZ2hpanN0dXZ\
3eHl6goOEhYaHiImKkpOUlZaXmJmaoqOkpaanqKmqsrO0tba3uLm6wsPExcbHyMnK0tPU1dbX2Nna4u\
Pk5ebn6Onq8vP09fb3+Pn6/9oADAMBAAIRAxEAPwD+/iiiigAooooAKKKKACiiigAooooAKKKKACiii\
gAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACii\
igAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACi\
iigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKAC\
iiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKA\
CiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKK\
ACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKK\
KACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKK\
KKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAK\
KKKACiiigAooooAKKKKACiiigAorz7/AISzUf8AnjZf9+5//kmj/hLNR/542X/fuf8A+SaAPQaK8+/4\
SzUf+eNl/wB+5/8A5JrY0TW7vUruSCeO3REt3mBiSRW3LJCgBLysNuJD27DmgDqaKKKACiiigAooooA\
KKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigDxeiiigArp/Cf8AyEZv+vKT/wBH21cxXT+E/w\
DkIzf9eUn/AKPtqAPQaKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigDxe\
iiigArp/Cf/ACEZv+vKT/0fbUUUAeg0UUUAFFFFABRRRQAUUUUAFFFFABRRRQAUUUUAFFFFABRRRQAU\
UUUAFFFFAH//2Q=='
	$end 'DesignInfo'
	$begin 'DesignInfo'
		DesignName='IcepakDesign1'
		Notes=''
		Factory='Icepak'
		IsSolved=false
		'Nominal Setups'[0:]
		'Nominal Setup Types'[0:]
		'Optimetrics Setups'[0:]
		'Optimetrics Experiment Types'[0:]
		Image64='/9j/4AAQSkZJRgABAQAAAQABAAD/2wBDAAEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQE\
BAQICAQECAQEBAgICAgICAgICAQICAgICAgICAgL/2wBDAQEBAQEBAQEBAQECAQEBAgICAgICAgICAg\
ICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgL/wAARCADIAMgDASIAAhEBAxEB/\
8QAHwAAAQUBAQEBAQEAAAAAAAAAAAECAwQFBgcICQoL/8QAtRAAAgEDAwIEAwUFBAQAAAF9AQIDAAQR\
BRIhMUEGE1FhByJxFDKBkaEII0KxwRVS0fAkM2JyggkKFhcYGRolJicoKSo0NTY3ODk6Q0RFRkdISUp\
TVFVWV1hZWmNkZWZnaGlqc3R1dnd4eXqDhIWGh4iJipKTlJWWl5iZmqKjpKWmp6ipqrKztLW2t7i5us\
LDxMXGx8jJytLT1NXW19jZ2uHi4+Tl5ufo6erx8vP09fb3+Pn6/8QAHwEAAwEBAQEBAQEBAQAAAAAAA\
AECAwQFBgcICQoL/8QAtREAAgECBAQDBAcFBAQAAQJ3AAECAxEEBSExBhJBUQdhcRMiMoEIFEKRobHB\
CSMzUvAVYnLRChYkNOEl8RcYGRomJygpKjU2Nzg5OkNERUZHSElKU1RVVldYWVpjZGVmZ2hpanN0dXZ\
3eHl6goOEhYaHiImKkpOUlZaXmJmaoqOkpaanqKmqsrO0tba3uLm6wsPExcbHyMnK0tPU1dbX2Nna4u\
Pk5ebn6Onq8vP09fb3+Pn6/9oADAMBAAIRAxEAPwD+/iiiigAooooAKKKKACiiigAooooAKKKKACiiv\
Jvij8fPgV8Dv7C/4XV8afhL8IP+Eo/tP/hGv+Fo/Ebwf8P/APhIv7F/s/8Atn+wv+Es1m0/tb7J/a2l\
favs/mfZ/wC07fzdnnR7sq+IoYWlKvia0MPRhbmnOShFXairyk0ldtJXeraS1Z6GV5TmueY+hleSZZi\
M4zPFc3ssNhaNTEV6nJCVSfs6NGM6k+SnCdSXLF8sIyk7Ri2vWaK+TP8Ahtz9ny8/0nwnqHxa+Kfh+T\
/jw8efAz9mj9pf4+/CzXdn7u6/4Rf4tfBX4Ra94Z8WfZb1bmzvf7M1a7+wajp13pl55GoWd3bQn/DQP\
xy1D/QNH/YU/aG0zVr3/RNL1Lx98Rv2PtD8C6fqNz+5sb7xrrXgb9pnxRrej+Eorl4pNSutH8NeItVt\
7OOaXT9C1e7SHT7jzv7cyuX+74r69bf6rCpi+Xtz/VoVfZ82vLz8vPaXLfllb7D/AIhdx3R/5G2Rf6q\
838P+3cVg8g9vb4/qv9t4jAfW/ZXj7f6t7X2HtKPtvZ+2pc/1nRXyZ9s/bq8U/wDEv/4Rz9kz4E+T/p\
n/AAl3/Ca/GH9rD+0fL/cf8I5/wrr/AIQH4L/2L532j7V/bX/CU3/2b+yPsP8AYF1/aX9o6Uf8KV/aU\
8Tf6f45/bQ8W+EtWh/0S3039mn4I/BH4eeBZ9Oj/fQ32raL+0X4Y+MGt3Xi1rm4u457q18S2OlPZ21h\
FBoVtdwX2oamf2pUn72GynF4ml/NyUqGvVezxVbD1lbu6ai/sth/qLgsN+6znxC4fyXHbuh9YzDNLRf\
wy+tZBlub5e+Za8kcZKrC1qtOm2k/rOiv5xvi/wDtkfFr4xfs+eAv2R/hr8Zvira/tGfHT/goH41/ZW\
0X9oixTwp4H8bap+zr4T8aaZ8dtM/aP+G+rfCGz0bT9W8MXH7KXj74HSQ6zpWm6Rba3beKrrUdPhksL\
q01G9+qf2Cf2x/HEP8AwTv+NHiT4yvqPxD/AGhP2ALb4+fC7446drviK8i8QeNvFf7O2l65rWlXWreJ\
tUtb67N1rPhaw0aG41i5gvZZ9Rhv7p1uZUkjPRluYUM0wGFzDDXVHFwUkpW5ovaUJ8spR54SThLllKP\
NF8spKzfj8a8JZrwHxXnvCGdOnPMshxE6E6lH2joV4q0qOJw7rUqNZ4fE0ZU8RQdajRqujVg6lKlNyh\
H9kKK/Db4E/wDBZLxb8T/HX7I1j8R/2IviJ8Ffg9+2dcHw18IfjPqnxS8KeLLTUviBbWEf2/Rh4L0zw\
/bX1v4VbX5Ba6fq9/Jp8+pWkianBpK2/nJBoaT/AMFjNZ8V/tE+NPhX8P8A9jX4kfEX4WfDn49ar+z9\
43+I/gj4k+C/E3xd0TxDoOstoOueMP8Ahk3RLG58Y3Xw4tbyO4nk1hQLdbK2kd9l7HJYJ3Hy5+3NFfl\
j4o/4Kd6H8OfEP/BRbwr8UfhX/wAIXrv7BngzQPiLotr/AMJ8upR/HvwX418O3ureBtT0SeXwZajwfd\
3utnw5pFzDjV47G+8Twxm4uGikSvBvit/wWG8dfD/V/gX8O/D/AOxpd+Mfjh8VP2aPCf7T/i34Z6p+0\
b8Pfhlb+CfCfjGe7i0/wh4S8RfELw3ZTfGD4jwrZXAuNG0nS4bxpQYLOK7eK6NuAfuPRXmPwX+JT/GL\
4U+A/ifL4G8e/DO48a+HLHW7v4f/ABQ8Naj4P8f+D76dWS+8P+KPD2qwRzWOo215FPHu2+VcRqlzbtJ\
bzRSMUAenUUUUAFFFeTfHz4o/8KO+BXxp+NX9hf8ACUf8Kg+EvxG+KP8AwjX9p/2L/wAJF/wr/wAH6z\
4s/sL+2f7Pu/7J+1/2T9n+1fZLr7P9o837PNs8tsq9elhqFbE15clHDwlOcrN2jBOUnZJt2Sbsk2+ib\
PQynKsfnma5ZkmVUPrWZ5xiKOFw1LmhD2lfEVI0aNPnqShThz1JxjzVJxhG95SjFNr1mivgn4Ra3+15\
+0T8J/hh8Y9O+NnwP+FngL46fDzwV8TLHwpoH7N3ivxH8WPhz4R+J3hvTPFNr4e0X4reKf2kJ/DmvfE\
PSNG1tLa28Q6j8O5tEutS05NSvPBcljJJoZ9D/wCGYfGGrf8AEv8AH37Y/wC1n8QPCVx/yFvCP9s/Ar\
4Qf2t5X7+w/wCLi/s0/ATwP428O+RqcVndf8SXxTpf2v7F9h1L7bpN1f6dd+VRzbEYqlSrYTJ69SliY\
xlSqTnhYU5Rmk4TlbETrQg01KVqMqkY3tSlJcj+7zDgDJ8izDHZdxB4j5ThMdk1arQxuEw+Gz3E42lV\
w83TxOGoKeUYfLsRioThOlSUszoYKrVSvj6VCX1hfWdfPPjn9rr9lD4X+KdU8DfEv9p79nn4eeNtD+x\
f214O8c/Gr4beEvFOj/2np1prGm/2p4e1/wAS293p/wBo0nULC6g82FPNtr2GePdFKjNyX/DDX7LWo/\
8AI/fC7/he3k/8gn/hqLxt8Rf2sP8AhFvM/wCP/wD4Qb/hpbxd4r/4QH7dss/7T/sX7B/av9kaf/aX2\
r+zbD7N9DeBvAPgT4X+FtL8DfDTwV4S+HngnQ/t39i+DvA3hzR/CXhbR/7T1G71jUv7L8PaBZ29pp/2\
jVtQv7qfyoU825vZp5N0srs2nNnlX3fZ4TA215+eti7/AN32fs8Hy3vfn9rK3Ly+zfNzQ5PZ+FmA/ff\
XOIOKub3fq/1bLsg5L6+2+ufW+Jfa8tvZ/VvqNLn9p7X63T9j7Gv88/8ADZXw2vP9E8O/DX9rPxH4gu\
v9G0Lw9/wxZ+1f4L/t3WJ/3WmaN/wmPxR+D2g+GfCf2q9aCD+0/EWu6LoVh5/2rV9W07T4ri8hP+F1f\
tKeJv8AQPA37F/i3wlq0P8ApdxqX7S3xu+CPw88Cz6dH+5msdJ1r9nTxP8AGDW7rxa1zcWkkFrdeGrH\
Sns7a/ln122u4LHT9T+s6KPqeZ1da+cOi1ssNQpU4v8AxLErGSb7OMoK28W9Q/1k4HwPuZV4cU8xp1N\
ZyzzNcwxlWMlolQlksuHKUKbWso1qGJqOWsasI+4fJn2P9urxT/xMP+Ej/ZM+BPk/6H/wiP8AwhXxh/\
aw/tHy/wB//wAJH/wsX/hPvgv/AGL532j7L/Yv/CLX/wBm/sj7d/b91/aX9naUf8M6/FrXP3njn9tL9\
obULbWPn8Y+DfAPh/8AZ5+F/gS9g1D5vEPhnwVq2j/BK5+IPw88JSxzXdrptza/EK48ZaRZvDLB4zl1\
u3XW2+s6KP7Hw89a+JxWJnL4nLFYiMZ9+alSqU6CT2cI0owaunHV3P8AiI+c0P3eVZNkeTYWn/BhRyH\
Ka9XDpfC6WYY/CYzNZVIP3oYitj62JhK0o1k4xt8mf8MR/s+Xn+jeLNP+LXxT8Pyf8f8A4D+Of7S/7S\
/x9+Fmu7P3lr/wlHwl+NXxd17wz4s+y3q215Zf2npN39g1HTrTU7PyNQs7S5h9a+F3wD+BXwO/t3/hS\
vwW+Evwg/4Sj+zP+El/4Vd8OfB/w/8A+Ei/sX+0P7G/t3/hE9GtP7W+yf2tqv2X7R5n2f8AtO48rZ50\
m71mitqGU5Vhasa+GyzD4etC/LOnRpwkrpxdpRimrptOz1Ta2PPzTxC4+zzAV8rzvjjOM4yzFcvtcNi\
szxuIoVOScakPaUa1edOfJUhCpHmi+WcIyVpRTRRRRXoHx4UUUUAfyz/DD/gnj4I/at+NH/BPfxv+2T\
4Q8IeNP2a/E/8AwSf+C/wv+Bmh6V47+JXhHW774u/DPwb8KviBPpXjPUvDg0RIvFd74Y+Ivxo1HQ9G0\
zW9Rm1HQvhXrOr3FrDDot75P2L4J/4JOeKP2cvHP7cXg79lG6+G/gn9kv8Aa5/ZE1z4Y6V8MvFHjv4o\
6v4l8DftB/8ACJeIvCXh/wATfate0LXZLv4fzW3iTW5tQuH1ifUY5ddZLbTntrC1gk9t8Lf8Uz/wSx/\
Yr+O9r+51b9lL9nn9lb9paO+i/f6jB4E+HfwX0C0/aE0nw9pdzmx1rxbrv7LviH44eG9Hg1IRWaar4z\
s7sX+i3dta67pnn3/BV744eGPh/wCI/gp8OdC/ad8WfAv9oL4kQala/C5rr4/aT8BfgN8OdMtfEfh6/\
wDE/wC0F8db2+vNPi8eWek6VpN/p2j+F9UvNRsPEE+q3dlbaBPciXULL5jherNYDDYOpa1PCYKtT5Uk\
lSrYeMbS2bqOvRxE5aNcs4Pmbcox/cfHTLsPPirOOJMK582Nz/ifLcW6s5TqTx2WZtOuqlNNyjHCRyn\
M8ow1FKUZe2w2Ki6MKcaVWuJ/wTj+Ny/C/wD4JJeCf+Eo+FX9q/sFfEDwX4r+MFwNb8W/2f4k0/w7ot\
pp1/D8Npf+EG8zWL17iB2iXVItHRlILyI2VHzJ+09/wSA/ax/aN+M/iTUtX+JH7Hx8I678XLD4g6H+1\
Hb/AAe1X4c/t0fD7w3YazYanpvg/TNV+EOkaN4a8bXWn2Vktnb6vrbS6nOALhri1byYbf1fRvjf8U4P\
+ChHizQfE3xm+Inh97H4+ftGaJ8RPAU3irUV8A/Dz9iXwp+xz4W8Z/Cj40Wfw/1ZLnQfD1sfjRLBJb+\
Lm09ptT1LVNR0e6u7y2tpLK3+VfCv7TnjjxT+zd+0D8Sv2c/2k/Hvjv4HXX7QX7IXgdYfiH+1RceJ/w\
BoXwF8Fv8AhONQ8K/HX4+fFPxzp0mra1+yV4W8f3MMQhRdPsv+EV0bw3qfiHStD0lXNnD9OfhxW/4KK\
fDHwP8Attf8FVvgZ+z18Dte8Wan4kk8L6Z8Lf8Agoho1t4N8VaP4V034C/Drx94A/aE8JW/iTxRqWiQ\
WGr3+pT28sNlcWclzEbxdGsmuQXNtX6G/wDBRj9gz9pD9qLxtoms/C+b9jL4k/DlPAc3g2X4Sftf/CC\
5vY/hzrM140lx8QPhH8W/hR4fi8X6Zqc9j9ljfSrnVF0pJbHz/Lm82OOzi8TfGXxXqH/BGH42fFnwZ4\
o+MHhnxX4f+Bv7QJ8K+O/EnxUv/GvxFguvBvibxxouieLfCvxu0vRNDv8Axx4Zkh0q2uPC3id7S01PV\
NBbTNRvZJr6ae6m8I+EV/8AtI2Pir9tz4UXfxc8e/s1+OPDX7LPw/8AGngT4feJ/jt8YP21pNb0PZ4q\
1XxT+018Gfit+0NNYaho63ong8KT6dHZNa+HdZ0qHUL3TrmR7FJwD9V/2E/2bte/ZD/ZN+DH7Onif4g\
XfxQ134ZeH9R03UfGV0l1FFeTat4j1rxGNK0mG+uJZofDumRazHpmmJK+5dP0e2Xy4QBDGVs/sSa/rv\
iv9jH9kbxT4p1vV/EvibxL+zD8A9f8R+I9f1K81nXdf13WfhV4T1HV9b1vV9RmkuNV1e61C5uJ7m5nk\
kmnmneWV2dmYlAH07RRRQAV8mft8f8AJiv7af8A2aZ+0b/6p7xlX1nXyZ+3x/yYr+2n/wBmmftG/wDq\
nvGVeVnv/Ijzn/sExH/pmZ+geE3/ACdTw0/7KDJv/Vjhg/Zv/wCKF8d/tJ/AK6/c/wDCHfFrVvjn4Gj\
uf9K1jWPhZ+1hrHiT4tXnijWdSsf9C/5OZ/4aj8PaZZLHZ6jZ6F8NtJfUrSf7Va69rv1nXyZ47/4tz+\
1t8EPHNv8AudJ/aH8JeLf2afGFvaf6XqOs+O/h3onjD9ov4B6tfQ6hiLRfCWheCfD37X1rdT6dNFeXu\
q/FTQoL+w1S0tre+8OfWdLKP3VHE4H/AKFtepRVvhVOXLXoQh1tTw9ajTd0rShJLmilOR4if7dmWScU\
x+HjTK8JmE3LStUxtL2uV5tiK6V4KpjM5y3McbFwnJToYijUmqVWdTD0SiiivWPz8KKKKACiiigAooo\
oAKKKKACvPPi78S9C+C/wn+J/xi8U2mrX/hn4T/Dzxr8S/EVjoEFnda7e6F4E8N6n4p1e00W11G/tbe\
51aTT9KuEto57q2heZ0WWeFC0i+h18mft8f8mK/tp/9mmftG/+qe8ZVwZpiKmEyzMcVRaVbDUK1SN1d\
c0KcpRuuqulddT6zgLJ8FxDxzwXkGZRlLLs8zbLsHXUJck3RxOMo0aqjJaxk4TlyyWzs+h1vwD+Cv8A\
wgX7KHwW/Z1+KNh4S8af8IX+zz8Ofgr8RdL+y/8ACR+BPFn/AAjnw20bwN4usPsPiLSof7d8JX/2PUI\
/KvrGL7VZ3Wy6tE3vCMj9kHX9dvvgfoXgjxprWreIPiN8C9W8Rfs+fEPXPFGpXl9418V678G9WuPBei\
/FPxnaatNLfaJq3j/wFp3g74iWtrfT3kx0j4s6ZdRanrNldWus6h9O18meBP8Ai3P7W3xv8DXH7nSf2\
h/CXhL9pbwfcXf+l6jrPjv4d6J4P/Z0+Pmk2U2n4i0XwloXgnw9+yDdWsGowxXl7qvxU12ewv8AVLS2\
uLHw5wzw9LLK+SOjeOHpReBfM9FTlTUqMpy6yVWhTo0+bRzxDjH35pP6fDZvjONsq8UI5nKNXN8dWjx\
PTjTj79XGUcXOlmNHDUNXGi8BmmLzPF+yTlTw+Twq1f8AZ8PUnT+s6KKK90/LAooooAKKKKACiiigAr\
5M/bX/AH/wN07R5v32k+Lf2hv2N/APirS5f3mneJvAnxE/bB+BXgb4geCvENi+Yta8Ja74J8Q6/o+sa\
bcrLZ6npWuXmn3sM9pczQv9Z18mftp/8ke8Hf8AZ2f7A/8A63V+zlXlZ7/yI85/7BMR/wCmZn6B4Tf8\
nU8NP+ygyb/1Y4Y1v2xtA13Wv2d/G2reFtF1bxX4m+F2rfDj9oPw74H0DTbzVNd+JGu/sz/FHwX+0Lp\
Hws0W306Ga4g1bxTqHwxt/D1tdQWt/NYzeJkvYtM1R7ddOufofQNf0LxXoWi+KfC2taT4l8M+JdJ03X\
/DviLQNSs9Y0LX9C1izh1HSNa0XV9Omkt9V0m60+5t57a5gkkhnhnSWJ2RlY61fJn7GH/FM/BtvgRdf\
udW/ZS8W65+zTJZS/v9Rg8CfDuDTbz9nvVvEOqW2bHWvFuu/su+Ifgf4k1ifTfKs01XxneWhsNFu7a6\
0LTFL9xnVOb+DMcO6d3olUw03OnCL2c6kMRXny/Fy0JSimozaKP/AAq+GWLw0NcRwbnCxahD3pzwueY\
WlhcXia0VeVPD4PFZPlWGVayp+3zalRqSVSrhoz+s6KKK9Y/PwooooAKKKKACiiigAooooAK+TP2+P+\
TFf20/+zTP2jf/AFT3jKvrOvkz9tz/AEz9nzUPCdz+88P/ABT+LX7NHwM8eWH3P7d+Fnx9/aX+EXwV+\
LXhf7VHifS/7W+Gfj3xZpn22zkt9RsP7V+2aZd2eoQW13D5We/8iPOf+wTEf+mZn6B4Tf8AJ1PDT/so\
Mm/9WOGPrOvkz9pD/ihfHf7Nnx9tf3P/AAh3xa0n4GeOZLb/AErWNY+Fn7WGseG/hLZ+F9G02+/0L/k\
5n/hlzxDqd60lnqNnoXw21ZNNu5/tV1oOu/WdeTfHz4Xf8Lx+BXxp+Cv9u/8ACL/8Lf8AhL8Rvhd/wk\
v9mf21/wAI7/wsDwfrPhP+3f7G/tC0/tb7J/a32j7L9rtftH2fyvtEO/zF1zWhVxGX4mGHjz4qCVWir\
pXr0ZKtQTcmlb2sIXu0mrptLU8/gHNMBlHF+R4nOK/1XIsVUngsyqcs5yhleY0qmX5nKEacZ1PaLL8V\
iXTdOE6kanLKEJSSi/WaK8m+BHxR/wCF1fBv4bfFKbQv+ES1bxl4S0nU/FXgaXU/7X1H4b+O44BY/ED\
4XeIbt9Ps5U8W+F/G1pr/AIf1i3ubKxvLPVfDd5aXtjZXcE1rD6zXVh69LFUKOJoT56GIhGpCVmrwnF\
Si7NJq6admk11SZ8/m2V4/I81zPJc0ofVczyfEVsLiaXNCfs6+HqSpVqfPTlOnPkqQlHmpzlCVrxlKL\
TZRRRWx54UUUUAFFFFABXyZ+2V/pnw2+Gvh20/0rxB4j/az/Ys/4R7Qrb9/rGu/8IX+1h8Hvij4x/sb\
TIsz6p/ZPwz8BeOfEWp+Qj/YNC8F6tq915Wn6deXEP1nXyZ+0b/yWH9gf/s7Pxl/6wr+2nXk5372WYi\
hssbKlhm/5Y4qtTw0pLu4RquST0bST0P0DwufsOOMozZe9U4Xp47PKcPs1auQ5fis6o0JveNPEVcBCj\
UlH3o06kpR95I+s6+TNH/4ob9tnxjo5/caT+0T+zz4e8faHpej/utOHjv9mvxvL4G+L/jXxjYnyYh4t\
1nwT+0B+zHo+n6lCt9eahpXwdbT9UmsLTw94fhvfrOvkz9r3/im/C3wk+NMXFz+z/8AtDfCfx9dXF9x\
4W0XwJ451G//AGdPjh418czL5bad4S8M/s+fHL4seJ5tSa6srPRrnwda61q802iadqVjdmcXpYWnjl8\
WV1I4h+VOKlDEafaf1apW5F/Py21QeHH+3Z5i+E5a0+PcHWyeMdnLGVp0sTk8XP8A5dU/7cwmWPEVLN\
LDKspLlkz6zooor1j8/CiiigAooooAKKKKACiiigAr5M/bT/5I94O/7Oz/AGB//W6v2cq+s6+TP20/+\
SPeDv8As7P9gf8A9bq/Zyrys9/5Eec/9gmI/wDTMz9A8Jv+TqeGn/ZQZN/6scMfWdFFFeqfn58mfs8f\
8UX8U/2rPgrL/wAS2y0L4tWHxz+HHhr/AI/Psvws/aT8O2/izxB4o/tlfNef+2v2ufDn7Xdx9iv7t9R\
077H5UFpYeGZPDEb/AFnXyZ8R/wDiiP2tv2bfHI/0bSfi94S+MX7NOuW+j/udR8R+O4dEsf2i/hBq3j\
GEeTFq/hLw34J+Cv7Tlrp8801zeaPqvxlaDS7AWniLxBfWn1nXk5T+7hjcF0y/EVKcbfCqdRRxNKEF9\
mFKjXp0YxVlFU7RSjyo/QPEL/bcXw1xNtLi7J8Fi6vNrVnisJKtkuYYnEVP+X2IzDMMqxeZVa0m6lWW\
M560p13UkyiiivWPz8KKKKACiiigAr5M/aN/5LD+wP8A9nZ+Mv8A1hX9tOvrOvkz4v8A/FU/tS/seeA\
f+PD/AIQ7/hoL9qL+1v8Aj6/tH/hW3w60z9mn/hBvsH7v7J9t/wCG0P7a/tPzpfs3/Ctv7N/s+f8Atj\
7fpXk51/udH/sLwH/qdhj7/wANf+SizH/sn+LP/WWzk+s65Lx94G8LfFDwL41+GnjnS/7c8E/ETwl4j\
8DeMdF+3ajpn9seFvFuj3mgeIdL/tLR7u3u9P8AtGk6hdxefazwXMXneZBNFKquvW0V6dSnCrCdKrBV\
KVROMoyScZRas4yTummm001ZrRnxGExeLwGLw2PwGJqYLHYKpCtRrUZyp1aNWnJTp1aVSDjOnUpzipw\
nBqUZJSi00mfPP7J3jnxT8RP2cvhFr/xC1T+2Pitp/hK38DfG27+w6dp/k/Hz4X3V38NPj1pfkaJaQa\
bJ9h+MfhLxvZefpCNotz/Z/wBp0aa40uWznl+hq+TPgv8A8UV+0b+1V8H7T954fvv+FRftReHoLb/iX\
aP4R/4X7a+P/h14x8DaN4di3wW/2n4mfs2eOfHup6nA9v8A2vrvx91aW609dQgvNX1v6zrz8nnUnluG\
hWm6tbDc+HnOTbdSphpyw86jbu37SdNz1bfvau9z7DxHwmFwvGec1sBhqeBy7O/q2bYXDUoRp08Lhc6\
wlDN8Lg4wgo04/VMPjaeGappU+ak/ZpQ5UFFfMWv/ALav7IfhrXda8Iaj+0x8D7nx7oGral4bvvhloH\
xL8KeK/ixP4u0q8m0y68CaL8KPC2qXniPxL8Q21mB9PtvD2naXda3eakyabZ2E99JHbtk/8NcaPrv+i\
fC74B/tZ/FPxBH/AKTeeHv+GdvHfwC+x6On7q41n/hMf2xLb4a+GdS8u9m0+D+zLHXbvXZv7R+1Wukz\
6fZ6peWClneUKUoRzKjWrRbXs6dSNWq2tHGNKm51JS/uxi5eRpR8L/EWrSpYqrwVmWX5fVjGf1zG4Wr\
gMBCnJKUatbMMbHD4KhRaaarVq9Ol70ff95X+s6K+TP8Ahan7W/ib/T/A37JXhLwlpMP+iXGm/tLftL\
aJ8PPHc+ox/vpr7SdF/Z0+Gfxg0S68JNbXFpHBdXXiWx1V7y2v4p9CtrSCx1DUz/hGv26tR/4mH/C6v\
2TPB32//TP+ER/4Zh+MPxJ/4Rb7V+//AOEc/wCFi/8ADXXhT/hPvsO/7L/bX/CLeGv7V+y/bv7A0fz/\
AOzraf7WjU0wuX4vFSW69hLD2Xe+MeGjL0hKUl1SWpp/xD+phPez7jHh/IKM9Kc/7VpZv7SW7j7PhuO\
d16Nlrz4mlQpS+GFSU/dPrOivkz/hmHxhq3/Ev8fftj/tZ/EDwlcf8hbwj/bPwK+EH9reV+/sP+Li/s\
0/ATwP428O+RqcVndf8SXxTpf2v7F9h1L7bpN1f6ddn/DDX7LWo/8AI/fC7/he3k/8gn/hqLxt8Rf2s\
P8AhFvM/wCP/wD4Qb/hpbxd4r/4QH7dss/7T/sX7B/av9kaf/aX2r+zbD7MfWs2q+9QymFGC0axOJjT\
qX7qOHpYyDhZ2TdWMuZSTgoqMpH9g+H2B/dZp4gYjMMRL3lPJMkq4zCqD0UalXOcdw7io4hSUnOnTwV\
WgqbpShip1J1aVDrfHP7XX7KHwv8AFOqeBviX+09+zz8PPG2h/Yv7a8HeOfjV8NvCXinR/wC09OtNY0\
3+1PD2v+Jbe70/7RpOoWF1B5sKebbXsM8e6KVGbkv+Gz/hLqf7rwN4V/aG+KFzqH7vwddeAf2XP2htQ\
8CfEOe7+Xw9ceCvjhrHw2sfh9e+EtXkktG03xXdeLLPwbLZ6hDq8/iK30Rm1JPobwN4B8CfC/wtpfgb\
4aeCvCXw88E6H9u/sXwd4G8OaP4S8LaP/aeo3esal/Zfh7QLO3tNP+0atqF/dT+VCnm3N7NPJulldm6\
2j2Wdz1eOw1BT3jHDVakoX+zGrLEwjNx2VSVCKk0pOjFPkD6/4X4b3KfC+eZrUw+ka9bOsDhaWJlDRV\
auBpZHiKuGp1mueeEp5rXqUYydGGYVZRWJl8mf8Lq/aU8Tf6B4G/Yv8W+EtWh/0u41L9pb43fBH4eeB\
Z9Oj/czWOk61+zp4n+MGt3Xi1rm4tJILW68NWOlPZ21/LPrttdwWOn6n4f8ZZv2krTXf2dfjh8YtN+B\
/g/wz8Iv2nfhHplj8G/hprXj34o674o139oW81T9jW18a3fx88U6B4Ot/Duk6Vp/7Uep6vJ4YT4c6jN\
eTfDuCNfF9umtyR6L+kdeefF34aaF8aPhP8T/AIO+KbvVrDwz8WPh541+GniK+0CeztddstC8d+G9T8\
Lavd6LdajYXVvbatHp+q3D20k9rcwpMiNLBMgaNuXHZRi62ErxWa4jF16a9pRhU+r04LEUmqmHnJ0cP\
RlJQrRhNwnKVKVrVITj7p7/AAr4h8P5ZxDldWpwFk+QZVi6n1PNK+EWcYvEyyfHRlg83w9GOZ5vmFKj\
UxOXV8TQjicPSpY6g6ntMHisNWUai9Dorw/9m34l678XPgf8PPG3jG00nTPiNLpNz4X+L2g6BBeQaF4\
V+OHw91bUfh78cfBmim9v7w3ek6L8XPC/jTSba6ivtRtLyHR0urHU9SspoL+49wr2cLiKeLw2HxdFt0\
cVCFSF1Z8s4qUbro7NXXQ/NM8yjGcP51m+QZjGMcwyTFYjB11CXPBVsNVnRqqMlZSipwlyy6qz6nzF+\
2XoGu63+zN8V9R8IaLq3ifx78N9J0j47/DLwpoum3mtXni/4sfs6+J9D+PXwo8HzaFpkL3uv6Tq3xG+\
HHhjTtQ0/T2g1K/sNTubPTbyxvpre8g+h9A1/QvFehaL4p8La1pPiXwz4l0nTdf8O+ItA1Kz1jQtf0L\
WLOHUdI1rRdX06aS31XSbrT7m3ntrmCSSGeGdJYnZGVjrV8mfse/8Ut4F8d/AJ/8Am1j4teJ/gZocdt\
++0fTvhZ/Y/hj4tfs6eF9G1K423uuf2B+zN8Vvg14e1O91OP8AtG513wpqz3N3rPya9qvBP/Z85pVH/\
DzKh7K72VTDSnVpwXd1KdbETd9lQ03Z9Zh/+Fjw1xuDp/7zwVmjzDkjrKeCzqjhcBjMRUv8NPB4zLco\
w8HHWVTNLSVoxa+s6KKK9Y/PwooooAKKKKACvgn9ojxr4k+Gn7Xf7LXi/RfhF8Q/i3BrfwP/AGt/hfZ\
6X8P9T+E+g3h8XeIvFf7J/wAQ9J0lNW+NHxP8I6PfatP4P+EnxD1CHSrTVLjW7mw8IarqVrpk+maNrN\
7p33tXyZ+2F/xS3gXwJ8fU/wCbWPi14Y+OeuSXP77R9O+Fn9j+J/hL+0X4o1nTbfbe65/YH7M3xW+Mv\
iHTLLTJP7Rudd8KaSltaaz8+g6r4vEEJTyqtONWVBYaph68pwUHONPDYiliKripxnByVOnLlUotN2Vt\
T9L8IMTRocfZXh62XUc2nnmFzbKaGGxEsRDD18XnOUY/KcFTrzwtfDYinRljMbQVWpSr05U4c03Lli0\
z/hPf22dQ/wBP0f8AZl/Z50zSb3/S9L03x9+19440Px3p+nXP76xsfGui+Bv2QPFGiaP4titnij1K10\
fxL4i0q3vI5otP13V7RIdQuD/hW/7ZGu/8SrxZ+1R8JfDnh+6/4/8AWfgZ+yrfeC/inZ+R/pNr/wAIv\
4l+NX7Q3xK8M6b5l7DbRXv9p+Cta87Tp7u3s/7O1CW01aw+s6K0/sr2n+95li8Xb4f331fl7/7lHC89\
7L+Lz8tvc5eafNyf6/fVP+RBwVw/w/7T+N/wm/2x7a38P/kpq2efV/Z3n/uX1X23P/tPt/ZYf2P5X/H\
b9mq88N/Ef9nL4q/Fb9o/9p34teGbb4h3PwD8VatqXxE0L4FXnw98I/tFxabovhvUNA1T9ibwV8MPEP\
iLVta/ac8HfsxeHHt9Uu/EGiWdh4pvdTvNHtEs28Q6J9O/8MIfsb3n+k+LP2bfhL8U/EEn/H/48+Ofh\
Sx+PvxT13Z+7tf+Eo+LXxqXXvE3iz7LZLbWdl/aerXf2DTtOtNMs/I0+ztLaH0P9pL4aa78XPgf8Q/B\
Pg670nTPiNLpNt4o+EOva/PeQaF4V+OHw91bTviF8DvGetCysLw3ek6L8XPC/gvVrm1lsdRtLyHR3tb\
7TNSspp7C4634RfEvQvjR8J/hh8YvC1pq1h4Z+LHw88FfEvw7Y6/BZ2uu2WheO/DemeKdItNatdOv7q\
3ttWj0/VbdLmOC6uYUmR1inmQLI3l0MkymlmuNoV8vpYt4yFPEQqYmP1itKUUqFaKrVuepKFKEMK0pS\
bjKq0pcjjGH3eaeJ/iDjeAOF80yri/HZB/q5isZk+IwmTVnk+XUMPWl/a2W1nl+W/VcJSxWOxOJz2M6\
lClThXp5fCU6SxEa9fFdboGgaF4U0LRfC3hbRdJ8NeGfDWk6boHh3w7oGm2ej6FoGhaPZw6dpGi6LpG\
nQx2+laTa6fbW8FtbQRxwwQwJFEioqqNaiivqYxjCMYQioxikkkrJJaJJLRJLZH4RWrVcRVq169WVev\
XlKc5zk5TnOTcpSlKTblKTbcpNttttu4UVyXjnx94E+F/hbVPHPxL8a+Evh54J0P7F/bXjHxz4j0fwl\
4W0f+09RtNH03+1PEOv3lvaaf8AaNW1CwtYPNmTzbm9hgj3SyorfPP/AA3L+y1qP/Ig/FH/AIXt5P8A\
yFv+GXfBPxF/aw/4RbzP+PD/AITn/hmnwj4r/wCEB+3bLz+zP7a+wf2r/ZGof2b9q/s2/wDs3Hiczy3\
BVFSxmYUMJVkuZRq1adOTi20pJSkm02mr2tdNdD6TJOCONOJcLUx3DnCGaZ/gaVR0ZVsFl+LxVKNWMY\
TlSlUoUakI1IwqU5ODakozhJq0ot/WdFfJn/DT3jDVv+Jh4B/Y4/az+IHhK4/5BPi7+xvgV8IP7W8r9\
xf/APFuv2lvj34H8beHfI1OK8tf+J14W0v7X9i+3ab9t0m6sNRuz/hJf26tR/4l/wDwpX9kzwd9v/0P\
/hLv+GnvjD8Sf+EW+1fuP+Ej/wCFdf8ADIvhT/hPvsO/7V/Yv/CU+Gv7V+y/Yf7f0fz/AO0bbm/trBy\
/hU8RiE/hlTwmKnTn2cKqo+xlCWjjUVT2bTUlPl949j/iGnElP/fsXk+Uyp/xqWL4gyKhisM1/Ep4nL\
55j/aFHEUdY1sHLCfXadSMqMsP7eLpn1nRXyZ/wqv9rfxN/oHjn9rXwl4S0mH/AEu31L9mn9mnRPh54\
7n1GP8Acw2Ora1+0X8TPjBol14Sa2uLuSe1tfDVjqr3ltYSwa7bWkF9p+pn/DI+j67/AKX8Ufj5+1n8\
U/EEf+jWfiH/AIaJ8d/AL7Ho6fvbfRv+EO/Y7ufhr4Z1Ly72bUJ/7TvtCu9dm/tH7LdatPp9npdnYH1\
7Manu0clqUp98RWw9OnbreVCpiql+yVJp9ZR3D/Vfg3B/vsy8TMHjsKtHTyjLc3xeN5ns40c2weQ4N0\
1/y8lLMI1Iq3JSqvRfTuv6/oXhTQta8U+Kda0nw14Z8NaTqWv+IvEWv6lZ6PoWgaFo9nNqOr61rWr6j\
NHb6VpNrp9tcT3NzPJHDBDA8srqisw+Yv8Ahu/9je8/0bwn+0l8Jfin4gk/48PAfwM8V2Px9+Keu7P3\
l1/wi/wl+Cra94m8WfZbJbm8vf7M0m7+wadp13qd55Gn2d3cw62gfsVfsh+Gtd0Xxfp37M/wPufHuga\
tpviSx+Juv/DTwp4r+LE/i7SryHU7Xx3rXxX8U6XeeI/EvxDbWYE1C58Q6jql1rd5qTPqV5fz30klw3\
07RbPKuvNhMBbpy1sXzefNzYLktty8k778y2Dm8LMB7nseIOLPaa+09rl3D3sracnsfY8TfWOb4va+3\
wvL8PsZ/Gflf8Cf2lbzw38R/wBo34VfCn9nD9p34teGbb4h23x88K6Tpvw70L4FXnw98I/tFxalrXiT\
T9f0v9tnxr8MPEPiLVta/ac8HftO+I0uNLtPEGiWdh4pstMs9YtEs18PaJ9O/wDCyP2yNd/4mvhP9lf\
4S+HPD91/x4aN8c/2qr7wX8U7PyP9Guv+Eo8NfBX9nn4leGdN8y9huZbL+zPGutedp09pcXn9nahLd6\
TYHxo/4or9o39lX4wXf7zw/ff8Ld/Zd8Qz3P8AxLtH8I/8L9tfAHxF8HeOdZ8RS74Lf7T8TP2bPA3gL\
TNMnS3/ALX134+6TFa6guoQWeka39Z15eV4HHR+u4Oec1qMsBWcYxo0sNCl7OpGFemqVOtQxFSnSpqq\
8PCLr1I/uXyOEbUqf3fHPFPC1V8M8SYXwzy3MKXFOW0q1armWNzzE4+WNwVavleMnj8bluaZRg8Xjsb\
UwMc2xNWGWYOq/wC04fWY4ms5Y/F/Jn/CBfts6h/oGsftNfs86ZpN7/omqal4B/ZB8caH470/Trn9zf\
X3grWvHP7X/ijRNH8WxWzyyabdax4a8RaVb3kcMuoaFq9ok2n3Hnn7O/grxJ8NP2u/2pfCGtfF34h/F\
uDW/gf+yR8ULzVPiBpnwn0G8Pi7xF4r/aw+Hmras+k/Bf4YeEdHvtWn8H/CT4eafNqt3pdxrdzYeENK\
0261OfTNG0ay0772r5M+EH/FU/tS/th+Pv8Ajw/4Q7/hn39l3+yf+Pr+0f8AhW3w61P9pb/hOft/7v7\
J9t/4bQ/sX+zPJl+zf8K2/tL+0J/7Y+waVtictw+GzDIatOpXlJYqorVMViq0dcDjPsVa04N9ny3XRo\
4Mk4zzjPOEPFrAY3B5TQoSyHCS5sHkOR5fWvHirhqyWJwGXYbEKL+1BVVCf2os+s6KKK+kPxMKKKKAC\
iiigArJ1/QNC8V6FrXhbxTouk+JfDPiXSdS0DxF4d1/TbPWNC1/QtYs5tO1fRda0jUYZLfVdJutPubi\
C5tp45IZ4Z3ilRkZlOtRSlGM4yhOKlGSaaaumno009Gmt0aUa1XD1aVehVlQr0JRnCcJOM4Ti1KMoyi\
04yi0nGSaaaTTufMX7Gmv67rf7M3wo07xfrWreJ/Hvw30nV/gR8TfFetalea1eeL/AIsfs6+J9c+Avx\
X8YQ67qcz3uv6Tq3xG+HHifUdP1DUFg1K/sNTtrzUrOxvprizg+na+TPhx/wAUR+1t+0l4GP8Ao2k/F\
7wl8Hf2ltDuNY/c6j4j8dw6Jffs6fF/SfB0x8mLV/CXhvwT8Ff2Y7rUIIYbm80fVfjKs+qX4tPEXh+x\
tPrOvMyaUll1ChOTnUwLnhpSb96bw85UVUknrF1owVZRbdlUXvTVpP7jxLo0v9cczzXDU40cHxVHD51\
RpwilSoQznD0sylg6UopQqxy6riamXSqxjTVSphJt0cPLmoUyvzc+DUP7SVprv7RXwP8Ag7qXwP8AB/\
hn4RftO/FzU774yfEvRfHvxR13xRrv7Qt5pf7ZV14KtPgH4W1/wdb+HdJ0rT/2o9M0iPxO/wARtRmvJ\
vh3PI3hC3TW45NF/SOvkz9iz/kj3jH/ALOz/b4/9bq/aNrmzGgsVmmV0FVnh5eyxU5zpzcZToxeHjPD\
3VpQVSrUoVXVpyjVj9X9nGSjVmevwdmksi4F46zWeAwucU3jsjw2Gw+MoQr0cNmVWGb18Pmzp1Oajip\
YTA4TM8vjgMZRr4Gs83+t1qUq2X4ZM/4Ur+0p4m/0/wAc/toeLfCWrQ/6Jb6b+zT8Efgj8PPAs+nR/v\
ob7VtF/aL8MfGDW7rxa1zcXcc91a+JbHSns7awig0K2u4L7UNTP+GMPhLqf73xz4q/aG+KFzqH7zxja\
+Pv2o/2htQ8CfEOe7+bxDb+Nfgfo/xJsfh9e+EtXkku11Lwpa+E7PwbLZ6hNpEHh230Rl01PrOit/7E\
yyX8fDvHJbLE1auKjF94xxNSrGD7yik2tGzzP+Io8cUdcqzenwvUl8dTI8Dl+Q1aq6Qr1slwuAq4inF\
+9GnWnUpxl78YqWp88+Bv2Rf2UPhf4p0vxz8NP2Yf2efh5420P7d/YvjHwN8Ffht4S8U6P/aenXej6l\
/ZfiHQPDVvd6f9o0nUL+1n8qZPNtr2aCTdFK6t9DUUV3YbCYTBU3SweFp4SlJ8zjShGnFyaScmopJuy\
Sva9kl0R8vnfEOf8S4qnjuI88xmf46lTVGFbG4mtiqsaUZTnGlGpXnUnGnGdSclBNRUpzkleTbKKKK6\
DxwooooAKKKKAPnn9rHwN4p+In7OXxd0D4e6X/bHxW0/wlceOfglafbtO0/yfj58L7q1+JfwF1Tz9bu\
4NNk+w/GPwl4IvfI1d20W5/s/7NrMNxpct5BL6z4B8c+Fvih4F8FfEvwNqn9ueCfiJ4S8OeOfB2tfYd\
R0z+2PC3i3R7PX/D2qf2brFpb3en/aNJ1C0l8i6gguYvO8ueGKVWRetr5M/ZC/4pvwt8W/gtLxc/s//\
tDfFjwDa29lx4W0XwJ451Gw/aL+B/grwNC3ltp3hLwz+z58cvhP4Yh01bWys9GufB11oukQzaJp2m31\
35NT/Z85oVNqeY0JUpN7e0w8nVowjbZzp1sVOd73VKPLy8suf9Awv/Cv4a5pg172J4LzSnmFOENJPB5\
xRpYDMsRXvfmp4fGZdkOHw7p+zcKmYVlVVdVaTw31nXyZ+zl/yWH9vj/s7Pwb/wCsK/sWV9Z18mfs5f\
8AJYf2+P8As7Pwb/6wr+xZTzH/AHvIv+wuf/qDjA4N/wCSc8Wf+yfw3/rVcMn1nRRRXqn5+FFFFABRR\
RQAUUUUAfJn7Q//ABRfxT/ZT+NUX/EtstC+LV/8DPiP4l/4/Psvws/aT8O3HhPw/wCF/wCxm815/wC2\
v2ufDn7Ilv8AbbC0fUdO+x+bPd2HhmTxPI/1nXk3x3+F3/C6vg38SfhbDrv/AAiWreMvCWraZ4V8cxa\
Z/a+o/Dfx3HAb74f/ABR8PWiahZyp4t8L+NrTQPEGj3Fte2N5Z6r4bs7uyvrK7ghuoT4B/FH/AIXj8C\
vgt8av7C/4Rf8A4W/8Jfhz8Uf+Ea/tP+2v+Ed/4WB4P0bxZ/YX9s/2faf2t9k/tb7P9q+yWv2j7P5v2\
eHf5a+TQ/2bNsbQekcxhDEwvq5Tpxhhq6VtIwhCOEaUkpSnVm4ykk40/v8ANf8AhZ8PuGM0h72I4PxG\
IyXExj7sKWExlXEZxlNSSn71XEYrFVuIqdSdGUqdOhgMLGrSoVJwq4z1mvkz9iz/AJI94x/7Oz/b4/8\
AW6v2ja+s6+TP2I/9M/Z80/xZbfvPD/xT+LX7S/xz8B3/ANz+3fhZ8ff2l/i78avhL4o+yyYn0v8Atb\
4Z+PfCep/YryO31Gw/tX7HqdpZ6hBc2kJW/wCR7l3/AGCY3/09gAy3/k1vGX/ZQcNf+q7iw+s6KKK9Y\
+ACiiigAooooAKKKKACiiigAr5M1j/ihv22fB2sD9xpP7RP7PPiHwDrmqax+604eO/2a/G8Xjn4QeCv\
B18PJiHi3WfBP7QH7TmsahpszX15qGlfB1dQ0uGwtPD3iCa9+s6+TP2z/wDimfg2vx3tf3OrfspeLdD\
/AGlo72L9/qMHgT4dwalZ/tCaT4e0u5zY614t139l3xD8cPDejwal5Vmmq+M7O7F/ot3bWuu6Z5Oc/u\
8E8YtJZZOGJuviVOlK9dQ6OdTDe2pRTtFudnKKfMv0Dw0/2ziinwzL3qPHGHxGSKEv4UsVmFN08pqYh\
q8o4fCZ0stx1WdOM6kI4Xnp0q84qjU+s6+TP2Nf9M+G3xK8RXf+leIPEf7Wf7af/CQ67c/v9Y13/hC/\
2sPjD8LvB39s6nLmfVP7J+GfgLwN4d0zz3f7BoXgvSdItfK0/TrO3h+s6+TP2LP+SPeMf+zs/wBvj/1\
ur9o2ivrnmWxeqWFxkkuikquBipeqjKUU90pSWzd1lfueGHGlSHu1KmecOUpSWjlSlguJ6sqTa1dOVW\
hQqSg/ddSjSm05U4NfWdFFFesfABRRRQAUUUUAFFFFABXyZ+zf/wAUL47/AGk/gFdfuf8AhDvi1q3xz\
8DR3P8ApWsax8LP2sNY8SfFq88UazqVj/oX/JzP/DUfh7TLJY7PUbPQvhtpL6laT/arXXtd+s6+TPHf\
/Fuf2tvgh45t/wBzpP7Q/hLxb+zT4wt7T/S9R1nx38O9E8YftF/APVr6HUMRaL4S0LwT4e/a+tbqfTp\
ory91X4qaFBf2GqWltb33hzycy/c1stxy09hXjRnb4pU8VagoLo19Ylhqk7tWjSbV5JQl+gcFf8KWW8\
b8LT9+WaZXWzDCqf8ABpY3Ir5pPETavONT+xqOdYLDuMJqVfHQp1FTpTniKP1nXyZ+wP8A8mK/sWf9m\
mfs5f8AqnvBtfWdfJn7A/8AyYr+xZ/2aZ+zl/6p7wbRW/5HuXf9gmN/9PYAWW/8mt4y/wCyg4a/9V3F\
h9Z0UUV6x8AFFFFABRRRQAUUUUAFFFFABWTr+gaF4r0LWvC3inRdJ8S+GfEuk6loHiLw7r+m2esaFr+\
haxZzadq+i61pGowyW+q6Tdafc3EFzbTxyQzwzvFKjIzKdailKMZxlCcVKMk001dNPRpp6NNbo0o1qu\
Hq0q9CrKhXoSjOE4ScZwnFqUZRlFpxlFpOMk000mnc+Yv2Odf13Wv2d/BOk+Kda1bxX4m+F2rfEf8AZ\
88ReONf1K81TXfiRrv7M/xR8afs9av8U9auNRmmuINW8U6h8MbjxDc2s91fzWM3iZ7KXU9Ue3bUbnJ/\
Yo/f/A3UdYh/faT4t/aG/bI8feFdUi/ead4m8CfET9sH46+Ofh/418PXyZi1rwlrvgnxDoGsaPqVs0t\
nqela5Z6hZTT2lzDM54E/4tz+1t8b/A1x+50n9ofwl4S/aW8H3F3/AKXqOs+O/h3ong/9nT4+aTZTaf\
iLRfCWheCfD37IN1awajDFeXuq/FTXZ7C/1S0trix8OH7A/wDyYr+xZ/2aZ+zl/wCqe8G18tlkpLHZR\
haknKtl+Ex2Gm2/ek6FfAU41JJ6xdemoYiMW37lWLUpxanL9343o0p8M+IGd4SnGnlvF+e8K51ho04r\
2FKOaZXxXi6+DoVIpU68cqxlTFZRVq04008TgK8J0cNVhUw9L6zooor6o/BAooooAKKKKACiiigAr5i\
/a+0DXb74H69438F6Lq3iD4jfAvVvDv7Qfw80Pwvpt5feNfFeu/BvVrfxprXws8GXekwy32iat4/8Ba\
d4x+Hd1dWMF5MdI+LOp2sumazZXV1o2ofTtFc2Nw0cbhMThJScFiIShzLVwck0px/vQdpRfSSTWp7nD\
OeVeGeIsk4go0I4ueTYqhiHRm2qeIhSqRlUw9W2ro4iClRrRs1OlOcZJptP55+Pnxq/4QL9lD40/tFf\
C6/8JeNP+EL/AGefiN8avh1qn2r/AISPwJ4s/wCEc+G2s+OfCN/9u8O6rD/bvhK/+x6fJ5tjfRfarO6\
32t2m9Jh6H8IvhpoXwX+E/wAMPg74Wu9Wv/DPwn+Hngr4aeHb7X57O61290LwJ4b0zwtpF3rV1p1ha2\
9zq0mn6VbvcyQWttC8zu0UEKFY1/NzxT/xTP8AwSx/bU+BF1+51b9lL9nn9qn9mmSxl/f6jB4E+HfwX\
1+7/Z71bxDqltmx1rxbrv7LviH4H+JNYn00xWaar4zvLQ2Gi3dtdaFpn6zV42V4mWPx31qtBQrQwOFf\
J/z5qVquJWJp66qSqYenTqRl70ZUVGSUk0fpHHeR0uEuFFkmX15V8DiOKs9gsQ0l/aOCy7AZJPI8beN\
4VKM8JnGLxeDq0m6VWjmMqtOVSlUpyCiiivoj8bCiiigAooooAKKKKACiiuS8c+PvAnwv8Lap45+Jfj\
Xwl8PPBOh/Yv7a8Y+OfEej+EvC2j/2nqNpo+m/2p4h1+8t7TT/ALRq2oWFrB5syebc3sMEe6WVFaKlS\
FKE6tWap0qacpSk0oxildyk3ZJJJttuyWrOjCYTF4/F4bAYDDVMbjsbUhRo0aMJVKtarUkoU6VKnBSn\
UqVJyUIQgnKUmoxTbSOtor5M/wCG5f2WtR/5EH4o/wDC9vJ/5C3/AAy74J+Iv7WH/CLeZ/x4f8Jz/wA\
M0+EfFf8AwgP27Zef2Z/bX2D+1f7I1D+zftX9m3/2Y/4ae8Yat/xMPAP7HH7WfxA8JXH/ACCfF39jfA\
r4Qf2t5X7i/wD+LdftLfHvwP428O+RqcV5a/8AE68LaX9r+xfbtN+26TdWGo3fmf25lMtKGOhjZ/yYb\
mxVRL+Z08Oqs1BNpObioJuKbTlFP7j/AIhZ4g0fezThfEcMYd6RxGdulkWFnPdUaeLzmpgcLUxEo804\
YanWlXnSp1asabp0asoH7SH/ABQvjv8AZs+Ptr+5/wCEO+LWk/AzxzJbf6VrGsfCz9rDWPDfwls/C+j\
abff6F/ycz/wy54h1O9aSz1Gz0L4basmm3c/2q60HXT9gf/kxX9iz/s0z9nL/ANU94Nrzz4u6J+15+0\
T8J/if8HNR+CfwP+FngL46fDzxr8M77xXr/wC0j4r8R/Fj4c+Efid4b1PwtdeIda+FPhb9m+fw5r3xD\
0jRtbe5ufD2nfESbRLrUtOfTbPxpJYyR64fp34B/C7/AIUd8Cvgt8Ff7d/4Sj/hUHwl+HPwu/4SX+zP\
7F/4SL/hX/g/RvCf9u/2N/aF3/ZP2v8Asn7R9l+13X2f7R5X2ibZ5jeXgoVa/ElbHUKFWGXSw0+adWl\
Uov61UlhoOMYVo06jj7DC0neMHBSUry5pWPu+JsRgMq8F8s4WzXNsDiOM6OdYdUsPgMfg8yprI8HQzn\
FUqtXEZbXxeDp1v7Uz7MIunVxEMVOlKk1R9lSVR+s0UUV9UfggUUUUAFFFFABRRRQAUUUUAfkz+3D/A\
MUNp3/BQPRz+40n9oj/AIJjfGzx9oel6P8AutOHjv8AZr8LeNvA3xf8a+MbE+TEPFus+Cf2gP2Y9H0/\
UoVvrzUNK+Drafqk1haeHvD8N7+s1fD/AO3t8DNY+Nvws+HFz4b8L+LfiB4g+EH7Q3wa+LA+GPhPW/A\
mi/8AC1PAkXiJ/hx8d/hr4lX4k6vpujeIPCWs/s5/Ef4v2d5o1/q2l2es/aI9MvrmbT7q70+963/hdX\
7Snib/AEDwN+xf4t8JatD/AKXcal+0t8bvgj8PPAs+nR/uZrHSda/Z08T/ABg1u68Wtc3FpJBa3Xhqx\
0p7O2v5Z9dtruCx0/U/ksLN5VnecxxFCu8LiI0J0JUsNiK8Wp1MVWrRlOjSnFTWIrVHyNqUacqenK03\
/Q+fUKfiB4X+GdTKM1yuGf5PiM1w2bUcdnWTZVVhLDYHh7LssqUsNmWPwtWeHqZTl2Dp/WKcJUquLoY\
xc3tIVIx+s6K+TPsf7dXin/iYf8JH+yZ8CfJ/0P8A4RH/AIQr4w/tYf2j5f7/AP4SP/hYv/CffBf+xf\
O+0fZf7F/4Ra/+zf2R9u/t+6/tL+ztKP8Ahn745ah/p+sft1/tDaZq17/peqab4B+HP7H2h+BdP1G5/\
fX1j4K0Xxz+zN4o1vR/CUVy8sem2useJfEWq29nHDFqGu6vdpNqFx6/9p15e9RybF1qT+GX+zUuZd/Z\
18TSrR9KlOEvLa/5x/qRlNH91mPiXw/luOhpUoXzrG+yl/L9ayrJcfl9ey158JjMRSeyqNppfWdeTfF\
H4+fAr4Hf2F/wur40/CX4Qf8ACUf2n/wjX/C0fiN4P+H/APwkX9i/2f8A2z/YX/CWazaf2t9k/tbSvt\
X2fzPs/wDadv5uzzo93kv/AAxH+z5ef6N4s0/4tfFPw/J/x/8AgP45/tL/ALS/x9+Fmu7P3lr/AMJR8\
JfjV8Xde8M+LPst6tteWX9p6Td/YNR0601Oz8jULO0uYfWvhd8A/gV8Dv7d/wCFK/Bb4S/CD/hKP7M/\
4SX/AIVd8OfB/wAP/wDhIv7F/tD+xv7d/wCET0a0/tb7J/a2q/ZftHmfZ/7TuPK2edJuOfPKnufVsJh\
L/wDLz21bEcvX+D7DC89/h/jw5b8/vW5JH1bwswn+0f2zxBxB7P8A5g/7My7J/bX93/kY/wBrZ59X9n\
f2v/IrxXtuT2H7j2v1ij5L/wANufs+Xn+k+E9Q+LXxT8Pyf8eHjz4Gfs0ftL/H34Wa7s/d3X/CL/Fr4\
K/CLXvDPiz7Lerc2d7/AGZq139g1HTrvTLzyNQs7u2hP+Givi1rn7vwN+xb+0NqFtrHyeDvGXj7xB+z\
z8L/AAJewah8vh7xN410nWPjbc/EH4eeEpY5rS61K2uvh7ceMtIs3min8GS63btojfWdFH1TNaulfN1\
RS2eGw8Kcm/7zxM8ZFrsoxg77yewf6wcA4H38q8PKmY1Kmk455nOJxlKMVqnQjkuH4bqwqN6SlWr4mm\
46RpQl758mfbP26vFP/Ev/AOEc/ZM+BPk/6Z/wl3/Ca/GH9rD+0fL/AHH/AAjn/Cuv+EB+C/8AYvnfa\
PtX9tf8JTf/AGb+yPsP9gXX9pf2jpR/wpX9pTxN/p/jn9tDxb4S1aH/AES3039mn4I/BH4eeBZ9Oj/f\
Q32raL+0X4Y+MGt3Xi1rm4u457q18S2OlPZ21hFBoVtdwX2oan9Z0Uf2RTn72JxuLxNX+b6zVoadF7P\
Cyw9HTuqak/tNh/xEPG4b91k3C/D+S4Faqh/YeX5paT+KX1rP6Ob5g+Z68ksZKlDalTpptP5M/wCGNf\
htef6X4i+JX7WfiPxBdf6TrviH/htP9q/wX/busT/vdT1n/hDvhd8YdB8M+E/tV608/wDZnh3QtF0Kw\
8/7LpGk6dp8VvZw9b4G/ZF/ZQ+F/inS/HPw0/Zh/Z5+HnjbQ/t39i+MfA3wV+G3hLxTo/8AaenXej6l\
/ZfiHQPDVvd6f9o0nUL+1n8qZPNtr2aCTdFK6t9DUVdPJcnpVIVYZXh41qbUlP2NN1FJNNT53Fzc00n\
zt819b31OfF+JniNjsLisBiuPM4q5djKc6NTC/wBpYuOFlQqRcJ4f6rGssOsO6bdP2Eaaoqn+7UFBKI\
UUUV6Z8OFFFFABRRRQAUUUUAFFFFABRRRQAUUUUAFFFFABRRRQAUUUUAFFFFABRRRQAUUUUAFFFFABR\
RRQAUUUUAFFFFAH/9k='
	$end 'DesignInfo'
$end 'ProjectPreview'
